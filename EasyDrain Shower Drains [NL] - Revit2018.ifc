Properties of the parts of a building model (IFC2X3), part 2 of 2

# IfcFlowTerminal: S-Line High met M2 sifonhuis onderuitloop, NLRS_PF_52_UN_S-Line TAF High_Easydrain:S-Line High met M2 sifonhuis onderuitloop:3086606
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: S-Line High met M2 sifonhuis onderuitloop

# IfcFlowTerminal: S-Line met M2 ondiep sifonhuis (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: S-Line met M2 ondiep sifonhuis
Name
NLRS_PF_52_UN_S-Line_Easydrain:S-Line met M2 ondiep sifonhuis:3086219
NLRS_PF_52_UN_Showerboard S-Line_Easydrain:S-Line met M2 ondiep sifonhuis:3373584

# IfcFlowTerminal: S-Line met M2 sifonhuis onderuitloop (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: S-Line met M2 sifonhuis onderuitloop
Name
NLRS_PF_52_UN_S-Line_Easydrain:S-Line met M2 sifonhuis onderuitloop:3086365
NLRS_PF_52_UN_Showerboard S-Line_Easydrain:S-Line met M2 sifonhuis onderuitloop:3373674

# IfcFlowTerminal: Slim Siphon & Slim Waste - Installatie optie 1, NLRS_PF_52_UN_Slim Siphon Slim Waste_Easydrain:Slim Siphon & Slim Waste - Installatie optie 1:3059050
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat); Material: NLRS_n6_ABS_verlijmbaar
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Slim Siphon & Slim Waste - Installatie optie 1

# IfcFlowTerminal: Slim Siphon & Slim Waste - Installatie optie 2, NLRS_PF_52_UN_Slim Siphon Slim Waste_Easydrain:Slim Siphon & Slim Waste - Installatie optie 2:3059160
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat); Material: NLRS_n6_ABS_verlijmbaar
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Slim Siphon & Slim Waste - Installatie optie 2

# IfcFlowTerminal: Slim Siphon & Slim Waste - Installatie optie 3, NLRS_PF_52_UN_Slim Siphon Slim Waste_Easydrain:Slim Siphon & Slim Waste - Installatie optie 3:3059453
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat); Material: NLRS_n6_ABS_verlijmbaar
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Slim Siphon & Slim Waste - Installatie optie 3

# IfcFlowTerminal: Slim Siphon XF & Slim Waste, NLRS_PF_52_UN_Slim Siphon XF Slim Waste_Easydrain:Slim Siphon XF & Slim Waste:3058928
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat); Material: NLRS_n6_ABS_verlijmbaar
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Slim Siphon XF & Slim Waste

# IfcFlowTerminal: Slim Tube (3)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat); Material: NLRS_n6_PVC_verlijmbaar
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Slim Tube
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Slim Tube drain pipe_Easydrain:Slim Tube:...)
3059643
3059717
3059788

# IfcFlowTerminal: Slim Tube - lengte 3,2 m (3)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat); Material: NLRS_n6_PVC_verlijmbaar
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Slim Tube - lengte 3,2 m
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Slim Tube drain pipe lengte 3,2m_Easydrain:Slim Tube - lengte 3,2 m:...)
3059869
3059951
3060013

# IfcFlowTerminal: Slim Tube outgoing facing down (2)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat); Material: NLRS_n6_PVC_verlijmbaar
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Slim Tube outgoing facing down
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Slim Tube outgoing facing down_Easydrain:Slim Tube outgoing facing down:...)
3059644
3059868

# IfcFlowTerminal: Slim Tube outgoing front (2)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat); Material: NLRS_n6_PVC_verlijmbaar
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Slim Tube outgoing front
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Slim Tube outgoing front_Easydrain:Slim Tube outgoing front:...)
3059718
3059950

# IfcFlowTerminal: Slim Tube outgoing rear (2)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat); Material: NLRS_n6_PVC_verlijmbaar
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Slim Tube outgoing rear
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Slim Tube outgoing rear_Easydrain:Slim Tube outgoing rear:...)
3059789
3060012

# IfcFlowTerminal: Slim Tube siphon connection (6)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat)
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Slim Tube siphon connection
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Slim Tube siphon connection_Easydrain:Slim Tube siphon connection:...)
3059642
3059716
3059787
3059867
3059949
3060011

# IfcFlowTerminal: Square Onderuitloop 50 mm, NLRS_PF_52_UN_Showerboard SQUARE_uitloop_Easydrain:Square Onderuitloop 50 mm:3373048
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, Default
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Square Onderuitloop 50 mm

# IfcFlowTerminal: Square Zijuitloop hoog 50 mm, NLRS_PF_52_UN_Showerboard SQUARE_uitloop_Easydrain:Square Zijuitloop hoog 50 mm:3372959
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, Default
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Square Zijuitloop hoog 50 mm

# IfcFlowTerminal: Square Zijuitloop laag 40 mm, NLRS_PF_52_UN_Showerboard SQUARE_uitloop_Easydrain:Square Zijuitloop laag 40 mm:3372786
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, Default
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Square Zijuitloop laag 40 mm

# IfcFlowTerminal: Square Zijuitloop laag 50 mm, NLRS_PF_52_UN_Showerboard SQUARE_uitloop_Easydrain:Square Zijuitloop laag 50 mm:3372866
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, Default
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Square Zijuitloop laag 50 mm

# IfcFlowTerminal: Square onderuitloop 50mm, zij-ingang 40mm, NLRS_PF_52_UN_Showerboard SQUARE_in_uitloop_Easydrain:Square onderuitloop 50mm, zij-ingang 40mm:3373208
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, Default
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Square onderuitloop 50mm, zij-ingang 40mm

# IfcFlowTerminal: Square onderuitloop 50mm, zij-ingang 50mm, NLRS_PF_52_UN_Showerboard SQUARE_in_uitloop_Easydrain:Square onderuitloop 50mm, zij-ingang 50mm:3373300
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, Default
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Square onderuitloop 50mm, zij-ingang 50mm

# IfcFlowTerminal: Square zijuitloop hoog 50mm, zij-ingang 40mm, NLRS_PF_52_UN_Showerboard SQUARE_in_uitloop_Easydrain:Square zijuitloop hoog 50mm, zij-ingang 40mm:3373130
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, Default
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Square zijuitloop hoog 50mm, zij-ingang 40mm

# IfcFlowTerminal: Tile 10x10 (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_52_WPS_ EasyDrain, Default, NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Tile 10x10
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Tile Complete_Easydrain:Tile 10x10:...)
3935441
3935622
3935708
3935717
3935746
3935755
3935779
3935788

# IfcFlowTerminal: Tile 10x10 (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_52_WPS_ EasyDrain, Roestvrijstaal,geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Tile 10x10
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain:Tile 10x10:...)
3053112
3053444
3060092
3060137
3064952
3064997
3083454
3083499

# IfcFlowTerminal: Tile 15x15 (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_52_WPS_ EasyDrain, Default, NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Tile 15x15
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Tile Complete_Easydrain:Tile 15x15:...)
3935566
3935625
3935711
3935720
3935749
3935758
3935782
3935791

# IfcFlowTerminal: Tile 15x15 (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_52_WPS_ EasyDrain, Roestvrijstaal,geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Tile 15x15
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain:Tile 15x15:...)
3053115
3053447
3060095
3060140
3064955
3065000
3083457
3083502

# IfcFlowTerminal: Tile 20x20 (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_52_WPS_ EasyDrain, Default, NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Tile 20x20
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Tile Complete_Easydrain:Tile 20x20:...)
3935573
3935628
3935714
3935723
3935752
3935761
3935785
3935794

# IfcFlowTerminal: Tile 20x20 (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_52_WPS_ EasyDrain, Roestvrijstaal,geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Tile 20x20
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain:Tile 20x20:...)
3053118
3053450
3060098
3060143
3064958
3065003
3083460
3083505

# IfcFlowTerminal: Vinyl M2-35, NLRS_PF_52_UN_Vinyl_Easydrain:Vinyl M2-35:3064626
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Vinyl M2-35

# IfcFlowTerminal: Vinyl M2-50, NLRS_PF_52_UN_Vinyl_Easydrain:Vinyl M2-50:3064747
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Vinyl M2-50

# IfcFlowTerminal: Vinyl M2-50 with M2 vertical outlet, NLRS_PF_52_UN_Vinyl_Easydrain:Vinyl M2-50 with M2 vertical outlet:3064866
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Vinyl M2-50 with M2 vertical outlet

# IfcFlowTerminal: WTW Aqua, NLRS_PF_52_UN_WTW systeem Aqua grate_Easydrain:WTW Aqua:3153924
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: Roestvrijstaal, geborsteld, ISR_groen
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: WTW Aqua

# IfcFlowTerminal: WTW Multi, NLRS_PF_52_UN_WTW systeem Multi grate_Easydrain:WTW Multi:3153974
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, ISR_groen
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: WTW Multi

# IfcFlowTerminal: White Glass 10x10 (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_52_WPS_ EasyDrain, NLRS_o_Glas_wit, Roestvrijstaal,geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: White Glass 10x10
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain:White Glass 10x10:...)
3053144
3053462
3060110
3060155
3064970
3065015
3083472
3083517

# IfcFlowTerminal: White Glass 15x15 (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_52_WPS_ EasyDrain, NLRS_o_Glas_wit, Roestvrijstaal,geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: White Glass 15x15
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain:White Glass 15x15:...)
3053147
3053465
3060113
3060158
3064973
3065018
3083475
3083520

# IfcFlowTerminal: White Glass 20x20 (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_52_WPS_ EasyDrain, NLRS_o_Glas_wit, Roestvrijstaal,geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: White Glass 20x20
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain:White Glass 20x20:...)
3053150
3053468
3060116
3060161
3064976
3065021
3083478
3083523

# IfcFlowTerminal: XS Nano (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: XS Nano
Name (NLRS_PF_52_UN_XS Nano_Easydrain:XS Nano:...)
3074293
3084028

# IfcFlowTerminal: XS Nano Wall (3)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: XS Nano Wall
Name (NLRS_PF_52_UN_XS Nano Wall_Easydrain:XS Nano Wall:...)
3074323
3084033
3962055

# IfcFlowTerminal: XS Nano Wall with M2 flat siphon (3)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: XS Nano Wall with M2 flat siphon
Name (NLRS_PF_52_UN_XS Nano Wall_Easydrain:XS Nano Wall with M2 flat siphon:...)
3074331
3084034
3962056

# IfcFlowTerminal: XS Nano Wall with M2 vertical outlet (3)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: XS Nano Wall with M2 vertical outlet
Name (NLRS_PF_52_UN_XS Nano Wall_Easydrain:XS Nano Wall with M2 vertical outlet:...)
3074341
3084036
3962058

# IfcFlowTerminal: XS Nano with M2 flat siphon (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: XS Nano with M2 flat siphon
Name (NLRS_PF_52_UN_XS Nano_Easydrain:XS Nano with M2 flat siphon:...)
3074301
3084029

# IfcFlowTerminal: XS Nano with M2 vertical outlet (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: XS Nano with M2 vertical outlet
Name (NLRS_PF_52_UN_XS Nano_Easydrain:XS Nano with M2 vertical outlet:...)
3074311
3084031

# IfcFlowTerminal: XS-Z1 Brushed (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: XS-Z1 Brushed
Name (NLRS_PF_52_UN_XS Z1 Complete Set_Easydrain:XS-Z1 Brushed:...)
3078751
3084038

# IfcFlowTerminal: XS-Z1 Brushed with M2 flat siphon (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: XS-Z1 Brushed with M2 flat siphon
Name (NLRS_PF_52_UN_XS Z1 Complete Set_Easydrain:XS-Z1 Brushed with M2 flat siphon:...)
3078756
3084039

# IfcFlowTerminal: XS-Z1 Brushed with M2 vertical outlet (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: XS-Z1 Brushed with M2 vertical outlet
Name (NLRS_PF_52_UN_XS Z1 Complete Set_Easydrain:XS-Z1 Brushed with M2 vertical outlet:...)
3078761
3084040

# IfcFlowTerminal: XS-Z1 Chrome Plated (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_verchroomt
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: XS-Z1 Chrome Plated
Name (NLRS_PF_52_UN_XS Z1 Complete Set_Easydrain:XS-Z1 Chrome Plated:...)
3078769
3084041

# IfcFlowTerminal: XS-Z1 Chrome Plated with M2 flat siphon (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_verchroomt
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: XS-Z1 Chrome Plated with M2 flat siphon
Name (NLRS_PF_52_UN_XS Z1 Complete Set_Easydrain:XS-Z1 Chrome Plated with M2 flat siphon:...)
3078770
3084042

# IfcFlowTerminal: XS-Z1 Chrome Plated with M2 vertical outlet (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_verchroomt
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: XS-Z1 Chrome Plated with M2 vertical outlet
Name (NLRS_PF_52_UN_XS Z1 Complete Set_Easydrain:XS-Z1 Chrome Plated with M2 vertical outlet:...)
3078771
3084043

# IfcFlowTerminal: XS-Z4 Brushed (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: XS-Z4 Brushed
Name (NLRS_PF_52_UN_XS Z4 Complete Set_Easydrain:XS-Z4 Brushed:...)
3083154
3084048

# IfcFlowTerminal: XS-Z4 Brushed with M2 flat siphon (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: XS-Z4 Brushed with M2 flat siphon
Name (NLRS_PF_52_UN_XS Z4 Complete Set_Easydrain:XS-Z4 Brushed with M2 flat siphon:...)
3083159
3084049

# IfcFlowTerminal: XS-Z4 Brushed with M2 vertical outlet (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: XS-Z4 Brushed with M2 vertical outlet
Name (NLRS_PF_52_UN_XS Z4 Complete Set_Easydrain:XS-Z4 Brushed with M2 vertical outlet:...)
3083164
3084050

# IfcFlowTerminal: XS-Z4 Chrome Plated (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_verchroomt
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: XS-Z4 Chrome Plated
Name (NLRS_PF_52_UN_XS Z4 Complete Set_Easydrain:XS-Z4 Chrome Plated:...)
3083169
3084051

# IfcFlowTerminal: XS-Z4 Chrome Plated with M2 flat siphon (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_verchroomt
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: XS-Z4 Chrome Plated with M2 flat siphon
Name (NLRS_PF_52_UN_XS Z4 Complete Set_Easydrain:XS-Z4 Chrome Plated with M2 flat siphon:...)
3083174
3084052

# IfcFlowTerminal: XS-Z4 Chrome Plated with M2 vertical outlet (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: XS-Z4 Chrome Plated with M2 vertical outlet
Name (NLRS_PF_52_UN_XS Z4 Complete Set_Easydrain:XS-Z4 Chrome Plated with M2 vertical outlet:...)
3083179
3084053

# IfcFlowTerminal: Zero+ Stainless Steel 10x10 (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_52_WPS_ EasyDrain, NLRS_h2_RVS_geborsteld, Roestvrijstaal,geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Zero+ Stainless Steel 10x10
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain:Zero+ Stainless Steel 10x10:...)
3051619
3053435
3060083
3060128
3064943
3064988
3083445
3083490

# IfcFlowTerminal: Zero+ Stainless Steel 15x15 (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_52_WPS_ EasyDrain, NLRS_h2_RVS_geborsteld, Roestvrijstaal,geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Zero+ Stainless Steel 15x15
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain:Zero+ Stainless Steel 15x15:...)
3051700
3053438
3060086
3060131
3064946
3064991
3083448
3083493

# IfcFlowTerminal: Zero+ Stainless Steel 20x20 (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_52_WPS_ EasyDrain, NLRS_h2_RVS_geborsteld, Roestvrijstaal,geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Zero+ Stainless Steel 20x20
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain:Zero+ Stainless Steel 20x20:...)
3051815
3053441
3060089
3060134
3064949
3064994
3083451
3083496

# IfcFlowTerminal: onderuitloop 50mm (33)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat)
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: onderuitloop 50mm
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon uitloop_Easydrain:onderuitloop 50mm:...)
3060449
3060501
3060571
3061101
3061526
3061598
3062070
3062438
3062783
3065046
3065054
3065062
3065088
3065102
3065116
3065130
3065144
3065158
3083548
3083556
3083564
3083590
3083604
3083618
3083632
3083646
3083660
3084117
3084125
3084133
3085198
3372372
3373049

# IfcFlowTerminal: onderuitloop 50mm, zij-ingang 40mm (33)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat)
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: onderuitloop 50mm, zij-ingang 40mm
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon in-uitloop_Easydrain:onderuitloop 50mm, zij-ingang 40mm:...)
3060625
3060633
3060641
3061262
3061530
3061602
3062380
3062444
3062933
3065066
3065072
3065078
3065092
3065106
3065120
3065136
3065150
3065162
3083568
3083574
3083580
3083594
3083608
3083622
3083638
3083652
3083664
3084137
3084143
3084149
3085332
3372565
3373209

# IfcFlowTerminal: onderuitloop 50mm, zij-ingang 50mm (27)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat)
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: onderuitloop 50mm, zij-ingang 50mm
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon in-uitloop_Easydrain:onderuitloop 50mm, zij-ingang 50mm:...)
3060627
3060635
3060643
3061368
3062252
3062442
3063007
3065068
3065074
3065080
3065094
3065134
3065148
3065164
3083570
3083576
3083582
3083596
3083636
3083650
3083666
3084139
3084145
3084151
3085384
3372661
3373301

# IfcFlowTerminal: zijuitloop hoog 50mm (33)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat)
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: zijuitloop hoog 50mm
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon uitloop_Easydrain:zijuitloop hoog 50mm:...)
3060431
3060499
3060569
3061044
3061524
3061596
3062003
3062436
3062713
3065044
3065052
3065060
3065086
3065100
3065114
3065128
3065142
3065156
3083546
3083554
3083562
3083588
3083602
3083616
3083630
3083644
3083658
3084115
3084123
3084131
3085098
3372300
3372960

# IfcFlowTerminal: zijuitloop hoog 50mm, zij-ingang 40mm (145)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat)
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: zijuitloop hoog 50mm, zij-ingang 40mm
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon in-uitloop_Easydrain:zijuitloop hoog 50mm, zij-ingang 40mm:...)
3053434
3053437
3053440
3053443
3053446
3053449
3053452
3053455
3053458
3053461
3053464
3053467
3053470
3053473
3053476
3054431
3054483
3058502
3058589
3058725
3058728
3060127
3060130
3060133
3060136
3060139
3060142
3060145
3060148
3060151
3060154
3060157
3060160
3060163
3060166
3060169
3060223
3060225
3060623
3060631
3060639
3061182
3061528
3061532
3061600
3061604
3062152
3062440
3062849
3064987
3064990
3064993
3064996
3064999
3065002
3065005
3065008
3065011
3065014
3065017
3065020
3065023
3065026
3065029
3065036
3065038
3065064
3065070
3065076
3065090
3065104
3065108
3065118
3065122
3065132
3065146
3065160
3069434
3069487
3069634
3069698
3070326
3070537
3072146
3072390
3072675
3072916
3083489
3083492
3083495
3083498
3083501
3083504
3083507
3083510
3083513
3083516
3083519
3083522
3083525
3083528
3083531
3083538
3083540
3083566
3083572
3083578
3083592
3083606
3083610
3083620
3083624
3083634
3083648
3083662
3083936
3083939
3083942
3083945
3083950
3083954
3083977
3083983
3083988
3083992
3084135
3084141
3084147
3085260
3085921
3086019
3372465
3373131
3935621
3935624
3935627
3935716
3935719
3935722
3935754
3935757
3935760
3935787
3935790
3935793

# IfcFlowTerminal: zijuitloop laag 40mm (137)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat)
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: zijuitloop laag 40mm
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon uitloop_Easydrain:zijuitloop laag 40mm:...)
3051618
3051699
3051814
3053111
3053114
3053117
3053127
3053130
3053133
3053143
3053146
3053149
3053161
3053164
3053167
3053821
3053903
3058131
3058214
3058309
3058368
3060082
3060085
3060088
3060091
3060094
3060097
3060100
3060103
3060106
3060109
3060112
3060115
3060118
3060121
3060124
3060219
3060221
3060247
3060495
3060565
3060669
3061520
3061592
3061634
3062432
3062479
3064942
3064945
3064948
3064951
3064954
3064957
3064960
3064963
3064966
3064969
3064972
3064975
3064978
3064981
3064984
3065032
3065034
3065040
3065048
3065056
3065082
3065096
3065110
3065124
3065138
3065152
3067915
3068591
3068657
3070154
3070457
3072081
3072314
3072498
3072796
3083444
3083447
3083450
3083453
3083456
3083459
3083462
3083465
3083468
3083471
3083474
3083477
3083480
3083483
3083486
3083534
3083536
3083542
3083550
3083558
3083584
3083598
3083612
3083626
3083640
3083654
3083924
3083927
3083930
3083948
3083952
3083974
3083980
3083986
3083990
3084111
3084119
3084127
3084811
3085763
3085833
3372090
3372787
3935440
3935565
3935572
3935707
3935710
3935713
3935745
3935748
3935751
3935778
3935781
3935784

# IfcFlowTerminal: zijuitloop laag 50mm (35)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat)
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: zijuitloop laag 50mm
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon uitloop_Easydrain:zijuitloop laag 50mm:...)
3060413
3060497
3060567
3060851
3061522
3061594
3061928
3062434
3062652
3065042
3065050
3065058
3065084
3065098
3065112
3065126
3065140
3065154
3068810
3083544
3083552
3083560
3083586
3083600
3083614
3083628
3083642
3083656
3083933
3084113
3084121
3084129
3084957
3372223
3372867
