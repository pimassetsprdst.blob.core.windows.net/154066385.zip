Properties of the parts of a building model (IFC2X3), part 2 of 9

# IfcFlowTerminal: Aqua Plus Delta horizontal outlet low 40mm (12)
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitloop; Manufacturer: Easy Sanitary Solutions; Model: Aqua Plus Delta; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Aqua Plus Delta horizontal outlet low 40mm; URL: https://www.easydrain.nl/doucheputten/aqua-plus-delta/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Aqua Plus Delta_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Plus Delta horizontal outlet low 40mm
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Build-in-Depth: 54 mm; Host: Level : Level 1
Dimensions - Outlet angle: 90 deg; D: 102 mm; Do: 40 mm; E: 20 mm; NLRS_C_hoogte: 54 mm; NLRS_P_c01_diameter: 40 mm; Z1: 91 mm
Identity Data - NLRS_C_omschrijving: Aqua Plus Delta
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Build_in_depth_calculated: 54 mm; Family: NLRS_PF_52_UN_Aqua Plus Delta_uitloop_Easydrain: Aqua Plus Delta horizontal outlet low 40mm; Family and Type: NLRS_PF_52_UN_Aqua Plus Delta_uitloop_Easydrain: Aqua Plus Delta horizontal outlet low 40mm; Flange Height: 25 mm; H_Siphon: 54 mm; Outlet depth: 34 mm; R: 51 mm; ro: 20 mm; Siphon Height: 54 mm; Type: NLRS_PF_52_UN_Aqua Plus Delta_uitloop_Easydrain: Aqua Plus Delta horizontal outlet low 40mm; Type Id: NLRS_PF_52_UN_Aqua Plus Delta_uitloop_Easydrain: Aqua Plus Delta horizontal outlet low 40mm; Waterseal: 30 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Aqua Plus Delta_uitloop_Easydrain:Aqua Plus Delta horizontal outlet low 40mm:...) | Zero | Flange | NLRS_C_breedte (mm) = NLRS_C_lengte (mm) | Volume (m3) | Mark | NLRS_C_code_product | Draingoot offset (mm) | Grate thickness (mm) | offset siphon (mm)
3060246 | no | no | 245 | 0.000260188 | 1421 | Aqua+WDE-MSI6 | 19 | 10 | -10
3060494 | no | yes | 240 | 0.00049899 | 1429 | EDMW-DE-MSI6 | 12 | 20 | -20
3060564 | yes | no | 240 | 0.00049899 | 1437 | EDMZW-DE-MSI6 | 12 | 20 | -20 | Identity Data - Design Option: Main Model
3065039 | no | no | 245 | 0.000260188 | 1705 | Aqua+WDE-MSI6 | 19 | 10 | -10 | Identity Data - Design Option: Main Model
3065047 | no | yes | 240 | 0.00049899 | 1713 | EDMW-DE-MSI6 | 12 | 20 | -20 | Identity Data - Design Option: Main Model
3065055 | yes | no | 240 | 0.00049899 | 1721 | EDMZW-DE-MSI6 | 12 | 20 | -20
3083541 | no | no | 245 | 0.000260188 | 2130 | Aqua+WDE-MSI6 | 19 | 10 | -10 | Identity Data - Design Option: Main Model
3083549 | no | yes | 240 | 0.00049899 | 2138 | EDMW-DE-MSI6 | 12 | 20 | -20
3083557 | yes | no | 240 | 0.00049899 | 2146 | EDMZW-DE-MSI6 | 12 | 20 | -20
3084110 | no | no | 245 | 0.000260188 | 2410 | Aqua+WDE-MSI6 | 19 | 10 | -10
3084118 | no | yes | 240 | 0.00049899 | 2418 | EDMW-DE-MSI6 | 12 | 20 | -20 | Identity Data - Design Option: Main Model
3084126 | yes | no | 240 | 0.00049899 | 2426 | EDMZW-DE-MSI6 | 12 | 20 | -20 | Identity Data - Design Option: Main Model

# IfcFlowTerminal: Aqua Plus Delta horizontal outlet low 50mm (12)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitloop; Manufacturer: Easy Sanitary Solutions; Model: Aqua Plus Delta; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Aqua Plus Delta horizontal outlet low 50mm; URL: https://www.easydrain.nl/doucheputten/aqua-plus-delta/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Aqua Plus Delta_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Plus Delta horizontal outlet low 50mm
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Build-in-Depth: 54 mm; Host: Level : Level 1
Dimensions - Outlet angle: 90 deg; D: 102 mm; Do: 50 mm; E: 25 mm; NLRS_C_hoogte: 54 mm; NLRS_P_c01_diameter: 50 mm; Z1: 91 mm
Identity Data - NLRS_C_omschrijving: Aqua Plus Delta
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Build_in_depth_calculated: 54 mm; Family: NLRS_PF_52_UN_Aqua Plus Delta_uitloop_Easydrain: Aqua Plus Delta horizontal outlet low 50mm; Family and Type: NLRS_PF_52_UN_Aqua Plus Delta_uitloop_Easydrain: Aqua Plus Delta horizontal outlet low 50mm; Flange Height: 25 mm; H_Siphon: 59 mm; Outlet depth: 34 mm; R: 51 mm; ro: 25 mm; Siphon Height: 59 mm; Type: NLRS_PF_52_UN_Aqua Plus Delta_uitloop_Easydrain: Aqua Plus Delta horizontal outlet low 50mm; Type Id: NLRS_PF_52_UN_Aqua Plus Delta_uitloop_Easydrain: Aqua Plus Delta horizontal outlet low 50mm; Waterseal: 30 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Aqua Plus Delta_uitloop_Easydrain:Aqua Plus Delta horizontal outlet low 50mm:...) | Zero | Flange | NLRS_C_breedte (mm) = NLRS_C_lengte (mm) | Volume (m3) | Design Option | Mark | NLRS_C_code_product | Draingoot offset (mm) | Grate thickness (mm) | offset siphon (mm)
3060412 | no | no | 245 | 0.000260188 | Main Model | 1423 | Aqua+WDE-MSI | 19 | 10 | -10
3060496 | no | yes | 240 | 0.00049899 | Main Model | 1431 | EDMW-DE-MSI | 12 | 20 | -20
3060566 | yes | no | 240 | 0.00049899 |  | 1439 | EDMZW-DE-MSI | 12 | 20 | -20
3065041 | no | no | 245 | 0.000260188 | Main Model | 1707 | Aqua+WDE-MSI | 19 | 10 | -10
3065049 | no | yes | 240 | 0.00049899 | Main Model | 1715 | EDMW-DE-MSI | 12 | 20 | -20
3065057 | yes | no | 240 | 0.00049899 | Main Model | 1723 | EDMZW-DE-MSI | 12 | 20 | -20
3083543 | no | no | 245 | 0.000260188 | Main Model | 2132 | Aqua+WDE-MSI | 19 | 10 | -10
3083551 | no | yes | 240 | 0.00049899 | Main Model | 2140 | EDMW-DE-MSI | 12 | 20 | -20
3083559 | yes | no | 240 | 0.00049899 | Main Model | 2148 | EDMZW-DE-MSI | 12 | 20 | -20
3084112 | no | no | 245 | 0.000260188 | Main Model | 2412 | Aqua+WDE-MSI | 19 | 10 | -10
3084120 | no | yes | 240 | 0.00049899 |  | 2420 | EDMW-DE-MSI | 12 | 20 | -20
3084128 | yes | no | 240 | 0.00049899 |  | 2428 | EDMZW-DE-MSI | 12 | 20 | -20

# IfcFlowTerminal: Aqua Plus Delta onderuitloop 50mm, zij-ingang 40mm (12)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot met onderuitloop; Manufacturer: Easy Sanitary Solutions; Model: Aqua Plus Delta; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Aqua Plus Delta onderuitloop 50mm, zij-ingang 40mm; URL: https://www.easydrain.nl/doucheputten/aqua-plus-delta/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Aqua Plus Delta_in_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Plus Delta onderuitloop 50mm, zij-ingang 40mm
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Build-in-Depth: 90 mm; Host: Level : Level 1
Dimensions - Outlet angle: 180 deg; D: 102 mm; Do1: 50 mm; Do2: 40 mm; E1: 0 mm; E2: 49 mm; NLRS_C_hoogte: 90 mm; NLRS_P_c01_diameter: 50 mm; NLRS_P_c02_diameter: 40 mm; Z1: 40 mm
Identity Data - NLRS_C_omschrijving: Aqua Plus Delta
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Build_in_depth_calculated: 90 mm; Family: NLRS_PF_52_UN_Aqua Plus Delta_in_uitloop_Easydrain: Aqua Plus Delta onderuitloop 50mm, zij-ingang 40mm; Family and Type: NLRS_PF_52_UN_Aqua Plus Delta_in_uitloop_Easydrain: Aqua Plus Delta onderuitloop 50mm, zij-ingang 40mm; Flange Height: 25 mm; H_Siphon: 90 mm; Inlet Depth: 41 mm; Inlet Length: 91 mm; Outlet depth: 90 mm; R: 51 mm; ro: 25 mm; Siphon Height: 90 mm; Type: NLRS_PF_52_UN_Aqua Plus Delta_in_uitloop_Easydrain: Aqua Plus Delta onderuitloop 50mm, zij-ingang 40mm; Type Id: NLRS_PF_52_UN_Aqua Plus Delta_in_uitloop_Easydrain: Aqua Plus Delta onderuitloop 50mm, zij-ingang 40mm; Waterseal: 35 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Aqua Plus Delta_in_uitloop_Easydrain:Aqua Plus Delta onderuitloop 50mm, zij-ingang 40mm:...) | Zero | Flange | NLRS_C_breedte (mm) = NLRS_C_lengte (mm) | Volume (m3) | Mark | NLRS_C_code_product | Draingoot offset (mm) | Grate thickness (mm) | offset siphon (mm)
3060624 | no | no | 245 | 0.000260188 | 1447 | Aqua+WDE-MSI4 | 19 | 10 | -10
3060632 | no | yes | 240 | 0.00049899 | 1455 | EDMW-DE-MSI4 | 12 | 20 | -20
3060640 | yes | no | 240 | 0.00049899 | 1463 | EDMZW-DE-MSI4 | 12 | 20 | -20 | Identity Data - Design Option: Main Model
3065065 | no | no | 245 | 0.000260188 | 1731 | Aqua+WDE-MSI4 | 19 | 10 | -10 | Identity Data - Design Option: Main Model
3065071 | no | yes | 240 | 0.00049899 | 1737 | EDMW-DE-MSI4 | 12 | 20 | -20
3065077 | yes | no | 240 | 0.00049899 | 1743 | EDMZW-DE-MSI4 | 12 | 20 | -20
3083567 | no | no | 245 | 0.000260188 | 2156 | Aqua+WDE-MSI4 | 19 | 10 | -10 | Identity Data - Design Option: Main Model
3083573 | no | yes | 240 | 0.00049899 | 2162 | EDMW-DE-MSI4 | 12 | 20 | -20 | Identity Data - Design Option: Main Model
3083579 | yes | no | 240 | 0.00049899 | 2168 | EDMZW-DE-MSI4 | 12 | 20 | -20
3084136 | no | no | 245 | 0.000260188 | 2436 | Aqua+WDE-MSI4 | 19 | 10 | -10 | Identity Data - Design Option: Main Model
3084142 | no | yes | 240 | 0.00049899 | 2442 | EDMW-DE-MSI4 | 12 | 20 | -20 | Identity Data - Design Option: Main Model
3084148 | yes | no | 240 | 0.00049899 | 2448 | EDMZW-DE-MSI4 | 12 | 20 | -20

# IfcFlowTerminal: Aqua Plus Delta onderuitloop 50mm, zij-ingang 50mm (12)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot met onderuitloop; Manufacturer: Easy Sanitary Solutions; Model: Aqua Plus Delta; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Aqua Plus Delta onderuitloop 50mm, zij-ingang 50mm; URL: https://www.easydrain.nl/doucheputten/aqua-plus-delta/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Aqua Plus Delta_in_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Plus Delta onderuitloop 50mm, zij-ingang 50mm
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Build-in-Depth: 90 mm; Host: Level : Level 1
Dimensions - Outlet angle: 180 deg; E1: 0 mm; D: 102 mm; Do1: 50 mm; Do2: 50 mm; E2: 54 mm; NLRS_C_hoogte: 90 mm; NLRS_P_c01_diameter: 50 mm; NLRS_P_c02_diameter: 50 mm; Z1: 40 mm
Identity Data - NLRS_C_omschrijving: Aqua Plus Delta
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Build_in_depth_calculated: 90 mm; Family: NLRS_PF_52_UN_Aqua Plus Delta_in_uitloop_Easydrain: Aqua Plus Delta onderuitloop 50mm, zij-ingang 50mm; Family and Type: NLRS_PF_52_UN_Aqua Plus Delta_in_uitloop_Easydrain: Aqua Plus Delta onderuitloop 50mm, zij-ingang 50mm; Flange Height: 25 mm; H_Siphon: 90 mm; Inlet Depth: 36 mm; Inlet Length: 91 mm; Outlet depth: 90 mm; R: 51 mm; ro: 25 mm; Siphon Height: 90 mm; Type: NLRS_PF_52_UN_Aqua Plus Delta_in_uitloop_Easydrain: Aqua Plus Delta onderuitloop 50mm, zij-ingang 50mm; Type Id: NLRS_PF_52_UN_Aqua Plus Delta_in_uitloop_Easydrain: Aqua Plus Delta onderuitloop 50mm, zij-ingang 50mm; Waterseal: 35 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Aqua Plus Delta_in_uitloop_Easydrain:Aqua Plus Delta onderuitloop 50mm, zij-ingang 50mm:...) | Zero | Flange | NLRS_C_breedte (mm) = NLRS_C_lengte (mm) | Volume (m3) | Mark | NLRS_C_code_product | Draingoot offset (mm) | Grate thickness (mm) | offset siphon (mm) | Design Option
3060626 | no | no | 245 | 0.000260188 | 1449 | Aqua+WDE-MSI5 | 19 | 10 | -10
3060634 | no | yes | 240 | 0.00049899 | 1457 | EDMW-DE-MSI5 | 12 | 20 | -20 | Main Model
3060642 | yes | no | 240 | 0.00049899 | 1465 | EDMZW-DE-MSI5 | 12 | 20 | -20 | Main Model
3065067 | no | no | 245 | 0.000260188 | 1733 | Aqua+WDE-MSI5 | 19 | 10 | -10 | Main Model
3065073 | no | yes | 240 | 0.00049899 | 1739 | EDMW-DE-MSI5 | 12 | 20 | -20
3065079 | yes | no | 240 | 0.00049899 | 1745 | EDMZW-DE-MSI5 | 12 | 20 | -20
3083569 | no | no | 245 | 0.000260188 | 2158 | Aqua+WDE-MSI5 | 19 | 10 | -10 | Main Model
3083575 | no | yes | 240 | 0.00049899 | 2164 | EDMW-DE-MSI5 | 12 | 20 | -20 | Main Model
3083581 | yes | no | 240 | 0.00049899 | 2170 | EDMZW-DE-MSI5 | 12 | 20 | -20 | Main Model
3084138 | no | no | 245 | 0.000260188 | 2438 | Aqua+WDE-MSI5 | 19 | 10 | -10
3084144 | no | yes | 240 | 0.00049899 | 2444 | EDMW-DE-MSI5 | 12 | 20 | -20 | Main Model
3084150 | yes | no | 240 | 0.00049899 | 2450 | EDMZW-DE-MSI5 | 12 | 20 | -20 | Main Model

# IfcFlowTerminal: Aqua Plus Delta vertical outlet 50mm (12)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot met onderuitloop; Manufacturer: Easy Sanitary Solutions; Model: Aqua Plus Delta; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Aqua Plus Delta vertical outlet 50mm; URL: https://www.easydrain.nl/doucheputten/aqua-plus-delta/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Aqua Plus Delta_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Plus Delta vertical outlet 50mm
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Build-in-Depth: 54 mm; Host: Level : Level 1
Dimensions - D: 102 mm; Do: 50 mm; E: 0 mm; NLRS_C_hoogte: 54 mm; NLRS_P_c01_diameter: 50 mm; Outlet angle: 180 deg; Z1: 40 mm
Identity Data - NLRS_C_omschrijving: Aqua Plus Delta
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Build_in_depth_calculated: 54 mm; Family: NLRS_PF_52_UN_Aqua Plus Delta_uitloop_Easydrain: Aqua Plus Delta vertical outlet 50mm; Family and Type: NLRS_PF_52_UN_Aqua Plus Delta_uitloop_Easydrain: Aqua Plus Delta vertical outlet 50mm; Flange Height: 25 mm; H_Siphon: 90 mm; Outlet depth: 90 mm; R: 51 mm; ro: 25 mm; Siphon Height: 90 mm; Type: NLRS_PF_52_UN_Aqua Plus Delta_uitloop_Easydrain: Aqua Plus Delta vertical outlet 50mm; Type Id: NLRS_PF_52_UN_Aqua Plus Delta_uitloop_Easydrain: Aqua Plus Delta vertical outlet 50mm; Waterseal: 35 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Aqua Plus Delta_uitloop_Easydrain:Aqua Plus Delta vertical outlet 50mm:...) | Zero | Flange | NLRS_C_breedte (mm) = NLRS_C_lengte (mm) | Volume (m3) | Mark | NLRS_C_code_product | Draingoot offset (mm) | Grate thickness (mm) | offset siphon (mm)
3060448 | no | no | 245 | 0.000260188 | 1427 | Aqua+WDE-MSI3 | 19 | 10 | -10
3060500 | no | yes | 240 | 0.00049899 | 1435 | EDMW-DE-MSI3 | 12 | 20 | -20
3060570 | yes | no | 240 | 0.00049899 | 1443 | EDMZW-DE-MSI3 | 12 | 20 | -20 | Identity Data - Design Option: Main Model
3065045 | no | no | 245 | 0.000260188 | 1711 | Aqua+WDE-MSI3 | 19 | 10 | -10 | Identity Data - Design Option: Main Model
3065053 | no | yes | 240 | 0.00049899 | 1719 | EDMW-DE-MSI3 | 12 | 20 | -20 | Identity Data - Design Option: Main Model
3065061 | yes | no | 240 | 0.00049899 | 1727 | EDMZW-DE-MSI3 | 12 | 20 | -20 | Identity Data - Design Option: Main Model
3083547 | no | no | 245 | 0.000260188 | 2136 | Aqua+WDE-MSI3 | 19 | 10 | -10 | Identity Data - Design Option: Main Model
3083555 | no | yes | 240 | 0.00049899 | 2144 | EDMW-DE-MSI3 | 12 | 20 | -20 | Identity Data - Design Option: Main Model
3083563 | yes | no | 240 | 0.00049899 | 2152 | EDMZW-DE-MSI3 | 12 | 20 | -20
3084116 | no | no | 245 | 0.000260188 | 2416 | Aqua+WDE-MSI3 | 19 | 10 | -10
3084124 | no | yes | 240 | 0.00049899 | 2424 | EDMW-DE-MSI3 | 12 | 20 | -20
3084132 | yes | no | 240 | 0.00049899 | 2432 | EDMZW-DE-MSI3 | 12 | 20 | -20

# IfcFlowTerminal: Aqua Plus Delta zijuitloop hoog 50mm, zij-ingang 40mm (12)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitloop; Manufacturer: Easy Sanitary Solutions; Model: Aqua Plus Delta; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Aqua Plus Delta zijuitloop hoog 50mm, zij-ingang 40mm; URL: https://www.easydrain.nl/doucheputten/aqua-plus-delta/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Aqua Plus Delta_in_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Plus Delta zijuitloop hoog 50mm, zij-ingang 40mm
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Build-in-Depth: 90 mm; Host: Level : Level 1
Dimensions - Outlet angle: 90 deg; D: 102 mm; Do1: 50 mm; Do2: 40 mm; E1: 54 mm; E2: 49 mm; NLRS_C_hoogte: 90 mm; NLRS_P_c01_diameter: 50 mm; NLRS_P_c02_diameter: 40 mm; Z1: 91 mm
Identity Data - NLRS_C_omschrijving: Aqua Plus Delta
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Build_in_depth_calculated: 90 mm; Family: NLRS_PF_52_UN_Aqua Plus Delta_in_uitloop_Easydrain: Aqua Plus Delta zijuitloop hoog 50mm, zij-ingang 40mm; Family and Type: NLRS_PF_52_UN_Aqua Plus Delta_in_uitloop_Easydrain: Aqua Plus Delta zijuitloop hoog 50mm, zij-ingang 40mm; Flange Height: 25 mm; H_Siphon: 90 mm; Inlet Depth: 41 mm; Inlet Length: 91 mm; Outlet depth: 36 mm; R: 51 mm; ro: 25 mm; Siphon Height: 90 mm; Type: NLRS_PF_52_UN_Aqua Plus Delta_in_uitloop_Easydrain: Aqua Plus Delta zijuitloop hoog 50mm, zij-ingang 40mm; Type Id: NLRS_PF_52_UN_Aqua Plus Delta_in_uitloop_Easydrain: Aqua Plus Delta zijuitloop hoog 50mm, zij-ingang 40mm; Waterseal: 50 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Aqua Plus Delta_in_uitloop_Easydrain:Aqua Plus Delta zijuitloop hoog 50mm, zij-ingang 40mm:...) | Zero | Flange | NLRS_C_breedte (mm) = NLRS_C_lengte (mm) | Volume (m3) | Mark | NLRS_C_code_product | Draingoot offset (mm) | Grate thickness (mm) | offset siphon (mm)
3060622 | no | no | 245 | 0.000260188 | 1445 | Aqua+WDE-MSI2 | 19 | 10 | -10
3060630 | no | yes | 240 | 0.00049899 | 1453 | EDMW-DE-MSI2 | 12 | 20 | -20
3060638 | yes | no | 240 | 0.00049899 | 1461 | EDMZW-DE-MSI2 | 12 | 20 | -20 | Identity Data - Design Option: Main Model
3065063 | no | no | 245 | 0.000260188 | 1729 | Aqua+WDE-MSI2 | 19 | 10 | -10
3065069 | no | yes | 240 | 0.00049899 | 1735 | EDMW-DE-MSI2 | 12 | 20 | -20
3065075 | yes | no | 240 | 0.00049899 | 1741 | EDMZW-DE-MSI2 | 12 | 20 | -20 | Identity Data - Design Option: Main Model
3083565 | no | no | 245 | 0.000260188 | 2154 | Aqua+WDE-MSI2 | 19 | 10 | -10 | Identity Data - Design Option: Main Model
3083571 | no | yes | 240 | 0.00049899 | 2160 | EDMW-DE-MSI2 | 12 | 20 | -20 | Identity Data - Design Option: Main Model
3083577 | yes | no | 240 | 0.00049899 | 2166 | EDMZW-DE-MSI2 | 12 | 20 | -20 | Identity Data - Design Option: Main Model
3084134 | no | no | 245 | 0.000260188 | 2434 | Aqua+WDE-MSI2 | 19 | 10 | -10
3084140 | no | yes | 240 | 0.00049899 | 2440 | EDMW-DE-MSI2 | 12 | 20 | -20
3084146 | yes | no | 240 | 0.00049899 | 2446 | EDMZW-DE-MSI2 | 12 | 20 | -20 | Identity Data - Design Option: Main Model

# IfcFlowTerminal: Aqua Plus Quattro Horizontal Outlet Low 40mm (3)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat)
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Aqua Plus Quattro; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Aqua Plus Quattro Horizontal Outlet Low 40mm; URL: https://www.easydrain.nl/doucheputten/aqua-plus-quattro/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Aqua Plus Quattro_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Plus Quattro Horizontal Outlet Low 40mm
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Build-in-Depth: 59 mm; Host: Level : Level 1
Dimensions - Outlet angle: 90 deg; D: 102 mm; Do: 40 mm; E: 20 mm; NLRS_C_breedte: 146 mm; NLRS_C_hoogte: 59 mm; NLRS_C_lengte: 146 mm; NLRS_P_c01_diameter: 40 mm; Tile Thickness: 6.5 mm; Volume: 0.000436978 m3; Z1: 91 mm
Identity Data - NLRS_C_code_product: Aqua+W15x15-MSI6; NLRS_C_omschrijving: Aqua Plus Quattro
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Build_in_depth_calculated: 59 mm; Family: NLRS_PF_52_UN_Aqua Plus Quattro_uitloop_Easydrain: Aqua Plus Quattro Horizontal Outlet Low 40mm; Family and Type: NLRS_PF_52_UN_Aqua Plus Quattro_uitloop_Easydrain: Aqua Plus Quattro Horizontal Outlet Low 40mm; Grate thickness: 14 mm; H_Siphon: 54 mm; offset siphon: -20.5 mm; Outlet depth: 39 mm; R: 51 mm; ro: 20 mm; Siphon Height: 59 mm; Tile Thickness Calculated: 6.5 mm; Type: NLRS_PF_52_UN_Aqua Plus Quattro_uitloop_Easydrain: Aqua Plus Quattro Horizontal Outlet Low 40mm; Type Id: NLRS_PF_52_UN_Aqua Plus Quattro_uitloop_Easydrain: Aqua Plus Quattro Horizontal Outlet Low 40mm; Wall edge: 40 mm; Waterseal: 30 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Aqua Plus Quattro_uitloop_Easydrain:Aqua Plus Quattro Horizontal Outlet Low 40mm:...) | Design Option | Mark
3060668 | Main Model | 1469
3065081 | Main Model | 1747
3083583 |  | 2172

# IfcFlowTerminal: Aqua Plus Quattro Horizontal outlet Low 50mm (3)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat)
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot verticale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Aqua Plus Quattro; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Aqua Plus Quattro Horizontal outlet Low 50mm; URL: https://www.easydrain.nl/doucheputten/aqua-plus-quattro/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Aqua Plus Quattro_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Plus Quattro Horizontal outlet Low 50mm
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Build-in-Depth: 59 mm; Host: Level : Level 1
Dimensions - Outlet angle: 90 deg; D: 102 mm; Do: 50 mm; E: 25 mm; NLRS_C_breedte: 146 mm; NLRS_C_hoogte: 59 mm; NLRS_C_lengte: 146 mm; NLRS_P_c01_diameter: 50 mm; Tile Thickness: 6.5 mm; Volume: 0.000436978 m3; Z1: 91 mm
Identity Data - Design Option: Main Model; NLRS_C_code_product: Aqua+W15x15-MSI; NLRS_C_omschrijving: Aqua Plus Quattro
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Build_in_depth_calculated: 59 mm; Family: NLRS_PF_52_UN_Aqua Plus Quattro_uitloop_Easydrain: Aqua Plus Quattro Horizontal outlet Low 50mm; Family and Type: NLRS_PF_52_UN_Aqua Plus Quattro_uitloop_Easydrain: Aqua Plus Quattro Horizontal outlet Low 50mm; Grate thickness: 14 mm; H_Siphon: 59 mm; offset siphon: -20.5 mm; Outlet depth: 34 mm; R: 51 mm; ro: 25 mm; Siphon Height: 59 mm; Tile Thickness Calculated: 6.5 mm; Type: NLRS_PF_52_UN_Aqua Plus Quattro_uitloop_Easydrain: Aqua Plus Quattro Horizontal outlet Low 50mm; Type Id: NLRS_PF_52_UN_Aqua Plus Quattro_uitloop_Easydrain: Aqua Plus Quattro Horizontal outlet Low 50mm; Wall edge: 40 mm; Waterseal: 30 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Aqua Plus Quattro_uitloop_Easydrain:Aqua Plus Quattro Horizontal outlet Low 50mm:...) | Mark
3060850 | 1471
3065083 | 1749
3083585 | 2174

# IfcFlowTerminal: Aqua Plus Quattro Horizontal outlet high 50mm (3)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat)
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot verticale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Aqua Plus Quattro; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Aqua Plus Quattro Horizontal outlet high 50mm; URL: https://www.easydrain.nl/doucheputten/aqua-plus-quattro/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Aqua Plus Quattro_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Plus Quattro Horizontal outlet high 50mm
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Build-in-Depth: 59 mm; Host: Level : Level 1
Dimensions - Outlet angle: 90 deg; D: 102 mm; Do: 50 mm; E: 54 mm; NLRS_C_breedte: 146 mm; NLRS_C_hoogte: 59 mm; NLRS_C_lengte: 146 mm; NLRS_P_c01_diameter: 50 mm; Tile Thickness: 6.5 mm; Volume: 0.000436978 m3; Z1: 91 mm
Identity Data - NLRS_C_code_product: Aqua+W15x15-MSI1; NLRS_C_omschrijving: Aqua Plus Quattro
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Build_in_depth_calculated: 59 mm; Family: NLRS_PF_52_UN_Aqua Plus Quattro_uitloop_Easydrain: Aqua Plus Quattro Horizontal outlet high 50mm; Family and Type: NLRS_PF_52_UN_Aqua Plus Quattro_uitloop_Easydrain: Aqua Plus Quattro Horizontal outlet high 50mm; Grate thickness: 14 mm; H_Siphon: 90 mm; offset siphon: -20.5 mm; Outlet depth: 36 mm; R: 51 mm; ro: 25 mm; Siphon Height: 90 mm; Tile Thickness Calculated: 6.5 mm; Type: NLRS_PF_52_UN_Aqua Plus Quattro_uitloop_Easydrain: Aqua Plus Quattro Horizontal outlet high 50mm; Type Id: NLRS_PF_52_UN_Aqua Plus Quattro_uitloop_Easydrain: Aqua Plus Quattro Horizontal outlet high 50mm; Wall edge: 40 mm; Waterseal: 50 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Aqua Plus Quattro_uitloop_Easydrain:Aqua Plus Quattro Horizontal outlet high 50mm:...) | Mark
3061043 | 1473
3065085 | 1751
3083587 | 2176 | Identity Data - Design Option: Main Model

# IfcFlowTerminal: Aqua Plus Quattro Vertical Outlet 50mm (3)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat)
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot verticale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Aqua Plus Quattro; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Aqua Plus Quattro Vertical Outlet 50mm; URL: https://www.easydrain.nl/doucheputten/aqua-plus-quattro/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Aqua Plus Quattro_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Plus Quattro Vertical Outlet 50mm
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Build-in-Depth: 59 mm; Host: Level : Level 1
Dimensions - E: 0 mm; Outlet angle: 180 deg; D: 102 mm; Do: 50 mm; NLRS_C_breedte: 146 mm; NLRS_C_hoogte: 59 mm; NLRS_C_lengte: 146 mm; NLRS_P_c01_diameter: 50 mm; Tile Thickness: 6.5 mm; Volume: 0.000436978 m3; Z1: 40 mm
Identity Data - NLRS_C_code_product: Aqua+W15x15-MSI3; NLRS_C_omschrijving: Aqua Plus Quattro
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Build_in_depth_calculated: 59 mm; Family: NLRS_PF_52_UN_Aqua Plus Quattro_uitloop_Easydrain: Aqua Plus Quattro Vertical Outlet 50mm; Family and Type: NLRS_PF_52_UN_Aqua Plus Quattro_uitloop_Easydrain: Aqua Plus Quattro Vertical Outlet 50mm; Grate thickness: 14 mm; H_Siphon: 90 mm; offset siphon: -20.5 mm; Outlet depth: 90 mm; R: 51 mm; ro: 25 mm; Siphon Height: 90 mm; Tile Thickness Calculated: 6.5 mm; Type: NLRS_PF_52_UN_Aqua Plus Quattro_uitloop_Easydrain: Aqua Plus Quattro Vertical Outlet 50mm; Type Id: NLRS_PF_52_UN_Aqua Plus Quattro_uitloop_Easydrain: Aqua Plus Quattro Vertical Outlet 50mm; Wall edge: 40 mm; Waterseal: 35 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Aqua Plus Quattro_uitloop_Easydrain:Aqua Plus Quattro Vertical Outlet 50mm:...) | Mark
3061100 | 1475 | Identity Data - Design Option: Main Model
3065087 | 1753
3083589 | 2178

# IfcFlowTerminal: Aqua Plus Quattro onderuitloop 50mm, zij-ingang 40mm (3)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat)
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot verticale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Aqua Plus Quattro; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Aqua Plus Quattro onderuitloop 50mm, zij-ingang 40mm; URL: https://www.easydrain.nl/doucheputten/aqua-plus-quattro/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Aqua Plus Quattro_in_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Plus Quattro onderuitloop 50mm, zij-ingang 40mm
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Build-in-Depth: 90 mm; Host: Level : Level 1
Dimensions - Outlet angle: 180 deg; E1: 0 mm; D: 102 mm; Do1: 50 mm; Do2: 40 mm; E2: 49 mm; NLRS_C_breedte: 146 mm; NLRS_C_hoogte: 90 mm; NLRS_C_lengte: 146 mm; NLRS_P_c01_diameter: 50 mm; NLRS_P_c02_diameter: 40 mm; Tile Thickness: 6.5 mm; Volume: 0.000436978 m3; Z1: 40 mm
Identity Data - NLRS_C_code_product: Aqua+W15x15-MSI4; NLRS_C_omschrijving: Aqua Plus Quattro
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Build_in_depth_calculated: 90 mm; Family: NLRS_PF_52_UN_Aqua Plus Quattro_in_uitloop_Easydrain: Aqua Plus Quattro onderuitloop 50mm, zij-ingang 40mm; Family and Type: NLRS_PF_52_UN_Aqua Plus Quattro_in_uitloop_Easydrain: Aqua Plus Quattro onderuitloop 50mm, zij-ingang 40mm; Grate thickness: 14 mm; H_Siphon: 90 mm; Inlet Depth: 41 mm; Inlet Length: 91 mm; offset siphon: -20.5 mm; Outlet depth: 90 mm; R: 51 mm; ro: 25 mm; Siphon Height: 90 mm; Tile Thickness Calculated: 6.5 mm; Type: NLRS_PF_52_UN_Aqua Plus Quattro_in_uitloop_Easydrain: Aqua Plus Quattro onderuitloop 50mm, zij-ingang 40mm; Type Id: NLRS_PF_52_UN_Aqua Plus Quattro_in_uitloop_Easydrain: Aqua Plus Quattro onderuitloop 50mm, zij-ingang 40mm; Wall edge: 40 mm; Waterseal: 35 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Aqua Plus Quattro_in_uitloop_Easydrain:Aqua Plus Quattro onderuitloop 50mm, zij-ingang 40mm:...) | Design Option | Mark
3061261 | Main Model | 1479
3065091 |  | 1757
3083593 | Main Model | 2182

# IfcFlowTerminal: Aqua Plus Quattro onderuitloop 50mm, zij-ingang 50mm (3)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat)
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot verticale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Aqua Plus Quattro; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Aqua Plus Quattro onderuitloop 50mm, zij-ingang 50mm; URL: https://www.easydrain.nl/doucheputten/aqua-plus-quattro/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Aqua Plus Quattro_in_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Plus Quattro onderuitloop 50mm, zij-ingang 50mm
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Build-in-Depth: 90 mm; Host: Level : Level 1
Dimensions - Outlet angle: 180 deg; E1: 0 mm; D: 102 mm; Do1: 50 mm; Do2: 50 mm; E2: 54 mm; NLRS_C_breedte: 146 mm; NLRS_C_hoogte: 90 mm; NLRS_C_lengte: 146 mm; NLRS_P_c01_diameter: 50 mm; NLRS_P_c02_diameter: 50 mm; Tile Thickness: 6.5 mm; Volume: 0.000436978 m3; Z1: 40 mm
Identity Data - NLRS_C_code_product: Aqua+W15x15-MSI5; NLRS_C_omschrijving: Aqua Plus Quattro
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Build_in_depth_calculated: 90 mm; Family: NLRS_PF_52_UN_Aqua Plus Quattro_in_uitloop_Easydrain: Aqua Plus Quattro onderuitloop 50mm, zij-ingang 50mm; Family and Type: NLRS_PF_52_UN_Aqua Plus Quattro_in_uitloop_Easydrain: Aqua Plus Quattro onderuitloop 50mm, zij-ingang 50mm; Grate thickness: 14 mm; H_Siphon: 90 mm; Inlet Depth: 36 mm; Inlet Length: 91 mm; offset siphon: -20.5 mm; Outlet depth: 90 mm; R: 51 mm; ro: 25 mm; Siphon Height: 90 mm; Tile Thickness Calculated: 6.5 mm; Type: NLRS_PF_52_UN_Aqua Plus Quattro_in_uitloop_Easydrain: Aqua Plus Quattro onderuitloop 50mm, zij-ingang 50mm; Type Id: NLRS_PF_52_UN_Aqua Plus Quattro_in_uitloop_Easydrain: Aqua Plus Quattro onderuitloop 50mm, zij-ingang 50mm; Wall edge: 40 mm; Waterseal: 35 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Aqua Plus Quattro_in_uitloop_Easydrain:Aqua Plus Quattro onderuitloop 50mm, zij-ingang 50mm:...) | Mark
3061367 | 1481
3065093 | 1759 | Identity Data - Design Option: Main Model
3083595 | 2184

# IfcFlowTerminal: Aqua Plus Quattro zijuitloop hoog 50mm, zij-ingang 40mm (3)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat)
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontal uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Aqua Plus Quattro; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Aqua Plus Quattro zijuitloop hoog 50mm, zij-ingang 40mm; URL: https://www.easydrain.nl/doucheputten/aqua-plus-quattro/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Aqua Plus Quattro_in_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Plus Quattro zijuitloop hoog 50mm, zij-ingang 40mm
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Build-in-Depth: 90 mm; Host: Level : Level 1
Dimensions - Outlet angle: 90 deg; D: 102 mm; Do1: 50 mm; Do2: 40 mm; E1: 54 mm; E2: 49 mm; NLRS_C_breedte: 146 mm; NLRS_C_hoogte: 90 mm; NLRS_C_lengte: 146 mm; NLRS_P_c01_diameter: 50 mm; NLRS_P_c02_diameter: 40 mm; Tile Thickness: 6.5 mm; Volume: 0.000436978 m3; Z1: 91 mm
Identity Data - NLRS_C_code_product: Aqua+W15x15-MSI2; NLRS_C_omschrijving: Aqua Plus Quattro
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Build_in_depth_calculated: 90 mm; Family: NLRS_PF_52_UN_Aqua Plus Quattro_in_uitloop_Easydrain: Aqua Plus Quattro zijuitloop hoog 50mm, zij-ingang 40mm; Family and Type: NLRS_PF_52_UN_Aqua Plus Quattro_in_uitloop_Easydrain: Aqua Plus Quattro zijuitloop hoog 50mm, zij-ingang 40mm; Grate thickness: 14 mm; H_Siphon: 90 mm; Inlet Depth: 41 mm; Inlet Length: 91 mm; offset siphon: -20.5 mm; Outlet depth: 36 mm; R: 51 mm; ro: 25 mm; Siphon Height: 90 mm; Tile Thickness Calculated: 6.5 mm; Type: NLRS_PF_52_UN_Aqua Plus Quattro_in_uitloop_Easydrain: Aqua Plus Quattro zijuitloop hoog 50mm, zij-ingang 40mm; Type Id: NLRS_PF_52_UN_Aqua Plus Quattro_in_uitloop_Easydrain: Aqua Plus Quattro zijuitloop hoog 50mm, zij-ingang 40mm; Wall edge: 40 mm; Waterseal: 50 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Aqua Plus Quattro_in_uitloop_Easydrain:Aqua Plus Quattro zijuitloop hoog 50mm, zij-ingang 40mm:...) | Design Option | Mark
3061181 | Main Model | 1477
3065089 | Main Model | 1755
3083591 |  | 2180

# IfcFlowTerminal: Aqua Quattro Horizontal Outlet Low 40mm (6)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat)
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Aqua Quattro; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Aqua Quattro Horizontal Outlet Low 40mm; URL: https://www.easydrain.nl/doucheputten/aqua-quattro/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Aqua Quattro_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Quattro Horizontal Outlet Low 40mm
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Tile: no; Build-in-Depth: 59 mm; Host: Level : Level 1
Dimensions - Outlet angle: 90 deg; D: 102 mm; Do: 40 mm; E: 20 mm; NLRS_C_hoogte: 59 mm; NLRS_P_c01_diameter: 40 mm; Tile Thickness: 0 mm; Z1: 91 mm
Identity Data - NLRS_C_omschrijving: Aqua Quattro - Brushed Stainless Steel
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Build_in_depth_calculated: 59 mm; Family: NLRS_PF_52_UN_Aqua Quattro_uitloop_Easydrain: Aqua Quattro Horizontal Outlet Low 40mm; Family and Type: NLRS_PF_52_UN_Aqua Quattro_uitloop_Easydrain: Aqua Quattro Horizontal Outlet Low 40mm; Grate thickness: 11 mm; H_Siphon: 54 mm; offset siphon: -11 mm; Outlet depth: 39 mm; R: 51 mm; ro: 20 mm; Siphon Height: 59 mm; Tile Thickness Calculated: 0 mm; Type: NLRS_PF_52_UN_Aqua Quattro_uitloop_Easydrain: Aqua Quattro Horizontal Outlet Low 40mm; Type Id: NLRS_PF_52_UN_Aqua Quattro_uitloop_Easydrain: Aqua Quattro Horizontal Outlet Low 40mm; Waterseal: 30 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Aqua Quattro_uitloop_Easydrain:Aqua Quattro Horizontal Outlet Low 40mm:...) | 10x10 | 15x15 | Area (m2) | NLRS_C_breedte (mm) = NLRS_C_lengte (mm) | Volume (m3) | Design Option | Mark | NLRS_C_code_product
3061519 | yes | no | 0.0122 | 100 | 0.00011 | Main Model | 1483 | AquaW10x10-MSI6
3061591 | no | yes | 0.024528 | 146 | 0.000234476 | Main Model | 1497 | AquaW15x15-MSI6
3065095 | yes | no | 0.0122 | 100 | 0.00011 | Main Model | 1761 | AquaW10x10-MSI6
3065109 | no | yes | 0.024528 | 146 | 0.000234476 | Main Model | 1775 | AquaW15x15-MSI6
3083597 | yes | no | 0.0122 | 100 | 0.00011 |  | 2186 | AquaW10x10-MSI6
3083611 | no | yes | 0.024528 | 146 | 0.000234476 |  | 2200 | AquaW15x15-MSI6

# IfcFlowTerminal: Aqua Quattro Horizontal outlet Low 50mm (6)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat)
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot verticale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Aqua Quattro; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Aqua Quattro Horizontal outlet Low 50mm; URL: https://www.easydrain.nl/doucheputten/aqua-quattro/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Aqua Quattro_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Quattro Horizontal outlet Low 50mm
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Tile: no; Build-in-Depth: 59 mm; Host: Level : Level 1
Dimensions - Outlet angle: 90 deg; Tile Thickness: 0 mm; D: 102 mm; Do: 50 mm; E: 25 mm; NLRS_C_hoogte: 59 mm; NLRS_P_c01_diameter: 50 mm; Z1: 91 mm
Identity Data - NLRS_C_omschrijving: Aqua Quattro - Brushed Stainless Steel
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Tile Thickness Calculated: 0 mm; Build_in_depth_calculated: 59 mm; Family: NLRS_PF_52_UN_Aqua Quattro_uitloop_Easydrain: Aqua Quattro Horizontal outlet Low 50mm; Family and Type: NLRS_PF_52_UN_Aqua Quattro_uitloop_Easydrain: Aqua Quattro Horizontal outlet Low 50mm; Grate thickness: 11 mm; H_Siphon: 59 mm; offset siphon: -11 mm; Outlet depth: 34 mm; R: 51 mm; ro: 25 mm; Siphon Height: 59 mm; Type: NLRS_PF_52_UN_Aqua Quattro_uitloop_Easydrain: Aqua Quattro Horizontal outlet Low 50mm; Type Id: NLRS_PF_52_UN_Aqua Quattro_uitloop_Easydrain: Aqua Quattro Horizontal outlet Low 50mm; Waterseal: 30 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Aqua Quattro_uitloop_Easydrain:Aqua Quattro Horizontal outlet Low 50mm:...) | 10x10 | 15x15 | Area (m2) | NLRS_C_breedte (mm) = NLRS_C_lengte (mm) | Volume (m3) | Mark | NLRS_C_code_product
3061521 | yes | no | 0.0122 | 100 | 0.00011 | 1485 | AquaW10x10-MSI
3061593 | no | yes | 0.024528 | 146 | 0.000234476 | 1499 | AquaW15x15-MSI | Identity Data - Design Option: Main Model
3065097 | yes | no | 0.0122 | 100 | 0.00011 | 1763 | AquaW10x10-MSI | Identity Data - Design Option: Main Model
3065111 | no | yes | 0.024528 | 146 | 0.000234476 | 1777 | AquaW15x15-MSI
3083599 | yes | no | 0.0122 | 100 | 0.00011 | 2188 | AquaW10x10-MSI
3083613 | no | yes | 0.024528 | 146 | 0.000234476 | 2202 | AquaW15x15-MSI

# IfcFlowTerminal: Aqua Quattro Horizontal outlet high 50mm (6)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat)
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot verticale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Aqua Quattro; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Aqua Quattro Horizontal outlet high 50mm; URL: https://www.easydrain.nl/doucheputten/aqua-quattro/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Aqua Quattro_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Quattro Horizontal outlet high 50mm
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Tile: no; Build-in-Depth: 59 mm; Host: Level : Level 1
Dimensions - Outlet angle: 90 deg; Tile Thickness: 0 mm; D: 102 mm; Do: 50 mm; E: 54 mm; NLRS_C_hoogte: 59 mm; NLRS_P_c01_diameter: 50 mm; Z1: 91 mm
Identity Data - NLRS_C_omschrijving: Aqua Quattro - Brushed Stainless Steel
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Tile Thickness Calculated: 0 mm; Build_in_depth_calculated: 59 mm; Family: NLRS_PF_52_UN_Aqua Quattro_uitloop_Easydrain: Aqua Quattro Horizontal outlet high 50mm; Family and Type: NLRS_PF_52_UN_Aqua Quattro_uitloop_Easydrain: Aqua Quattro Horizontal outlet high 50mm; Grate thickness: 11 mm; H_Siphon: 90 mm; offset siphon: -11 mm; Outlet depth: 36 mm; R: 51 mm; ro: 25 mm; Siphon Height: 90 mm; Type: NLRS_PF_52_UN_Aqua Quattro_uitloop_Easydrain: Aqua Quattro Horizontal outlet high 50mm; Type Id: NLRS_PF_52_UN_Aqua Quattro_uitloop_Easydrain: Aqua Quattro Horizontal outlet high 50mm; Waterseal: 50 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Aqua Quattro_uitloop_Easydrain:Aqua Quattro Horizontal outlet high 50mm:...) | 10x10 | 15x15 | Area (m2) | NLRS_C_breedte (mm) = NLRS_C_lengte (mm) | Volume (m3) | Mark | NLRS_C_code_product
3061523 | yes | no | 0.0122 | 100 | 0.00011 | 1487 | AquaW10x10-MSI1
3061595 | no | yes | 0.024528 | 146 | 0.000234476 | 1501 | AquaW15x15-MSI1
3065099 | yes | no | 0.0122 | 100 | 0.00011 | 1765 | AquaW10x10-MSI1
3065113 | no | yes | 0.024528 | 146 | 0.000234476 | 1779 | AquaW15x15-MSI1
3083601 | yes | no | 0.0122 | 100 | 0.00011 | 2190 | AquaW10x10-MSI1
3083615 | no | yes | 0.024528 | 146 | 0.000234476 | 2204 | AquaW15x15-MSI1 | Identity Data - Design Option: Main Model

# IfcFlowTerminal: Aqua Quattro Vertical Outlet 50mm (6)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat)
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot verticale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Aqua Quattro; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Aqua Quattro Vertical Outlet 50mm; URL: https://www.easydrain.nl/doucheputten/aqua-quattro/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Aqua Quattro_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Quattro Vertical Outlet 50mm
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Tile: no; Build-in-Depth: 59 mm; Host: Level : Level 1
Dimensions - E: 0 mm; Outlet angle: 180 deg; Tile Thickness: 0 mm; D: 102 mm; Do: 50 mm; NLRS_C_hoogte: 59 mm; NLRS_P_c01_diameter: 50 mm; Z1: 40 mm
Identity Data - NLRS_C_omschrijving: Aqua Quattro - Brushed Stainless Steel
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Tile Thickness Calculated: 0 mm; Build_in_depth_calculated: 59 mm; Family: NLRS_PF_52_UN_Aqua Quattro_uitloop_Easydrain: Aqua Quattro Vertical Outlet 50mm; Family and Type: NLRS_PF_52_UN_Aqua Quattro_uitloop_Easydrain: Aqua Quattro Vertical Outlet 50mm; Grate thickness: 11 mm; H_Siphon: 90 mm; offset siphon: -11 mm; Outlet depth: 90 mm; R: 51 mm; ro: 25 mm; Siphon Height: 90 mm; Type: NLRS_PF_52_UN_Aqua Quattro_uitloop_Easydrain: Aqua Quattro Vertical Outlet 50mm; Type Id: NLRS_PF_52_UN_Aqua Quattro_uitloop_Easydrain: Aqua Quattro Vertical Outlet 50mm; Waterseal: 35 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Aqua Quattro_uitloop_Easydrain:Aqua Quattro Vertical Outlet 50mm:...) | 10x10 | 15x15 | Area (m2) | NLRS_C_breedte (mm) = NLRS_C_lengte (mm) | Volume (m3) | Mark | NLRS_C_code_product
3061525 | yes | no | 0.0122 | 100 | 0.00011 | 1489 | AquaW10x10-MSI3 | Identity Data - Design Option: Main Model
3061597 | no | yes | 0.024528 | 146 | 0.000234476 | 1503 | AquaW15x15-MSI3 | Identity Data - Design Option: Main Model
3065101 | yes | no | 0.0122 | 100 | 0.00011 | 1767 | AquaW10x10-MSI3
3065115 | no | yes | 0.024528 | 146 | 0.000234476 | 1781 | AquaW15x15-MSI3 | Identity Data - Design Option: Main Model
3083603 | yes | no | 0.0122 | 100 | 0.00011 | 2192 | AquaW10x10-MSI3
3083617 | no | yes | 0.024528 | 146 | 0.000234476 | 2206 | AquaW15x15-MSI3

# IfcFlowTerminal: Aqua Quattro onderuitloop 50mm, zij-ingang 40mm (6)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat)
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot verticale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Aqua Quattro; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Aqua Quattro onderuitloop 50mm, zij-ingang 40mm; URL: https://www.easydrain.nl/doucheputten/aqua-quattro/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Aqua Quattro_in_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Quattro onderuitloop 50mm, zij-ingang 40mm
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Tile: no; Build-in-Depth: 90 mm; Host: Level : Level 1
Dimensions - Outlet angle: 180 deg; E1: 0 mm; Tile Thickness: 0 mm; D: 102 mm; Do1: 50 mm; Do2: 40 mm; E2: 49 mm; NLRS_C_hoogte: 90 mm; NLRS_P_c01_diameter: 50 mm; Z1: 40 mm
Identity Data - NLRS_C_omschrijving: Aqua Quattro - Brushed Stainless Steel
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Tile Thickness Calculated: 0 mm; Build_in_depth_calculated: 90 mm; Family: NLRS_PF_52_UN_Aqua Quattro_in_uitloop_Easydrain: Aqua Quattro onderuitloop 50mm, zij-ingang 40mm; Family and Type: NLRS_PF_52_UN_Aqua Quattro_in_uitloop_Easydrain: Aqua Quattro onderuitloop 50mm, zij-ingang 40mm; Grate thickness: 11 mm; H_Siphon: 90 mm; Inlet Depth: 41 mm; Inlet Length: 91 mm; offset siphon: -11 mm; Outlet depth: 90 mm; R: 51 mm; ro: 25 mm; Siphon Height: 90 mm; Type: NLRS_PF_52_UN_Aqua Quattro_in_uitloop_Easydrain: Aqua Quattro onderuitloop 50mm, zij-ingang 40mm; Type Id: NLRS_PF_52_UN_Aqua Quattro_in_uitloop_Easydrain: Aqua Quattro onderuitloop 50mm, zij-ingang 40mm; Waterseal: 35 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Aqua Quattro_in_uitloop_Easydrain:Aqua Quattro onderuitloop 50mm, zij-ingang 40mm:...) | 10x10 | 15x15 | Area (m2) | NLRS_C_breedte (mm) = NLRS_C_lengte (mm) | Volume (m3) | Design Option | Mark | NLRS_C_code_product
3061529 | yes | no | 0.0122 | 100 | 0.00011 | Main Model | 1493 | AquaW10x10-MSI4
3061601 | no | yes | 0.024528 | 146 | 0.000234476 | Main Model | 1507 | AquaW15x15-MSI4
3065105 | yes | no | 0.0122 | 100 | 0.00011 |  | 1771 | AquaW10x10-MSI4
3065119 | no | yes | 0.024528 | 146 | 0.000234476 |  | 1785 | AquaW15x15-MSI4
3083607 | yes | no | 0.0122 | 100 | 0.00011 | Main Model | 2196 | AquaW10x10-MSI4
3083621 | no | yes | 0.024528 | 146 | 0.000234476 | Main Model | 2210 | AquaW15x15-MSI4

# IfcFlowTerminal: Aqua Quattro zijuitloop hoog 50mm, zij-ingang 40mm (12)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat)
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Aqua Quattro; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Aqua Quattro zijuitloop hoog 50mm, zij-ingang 40mm; URL: https://www.easydrain.nl/doucheputten/aqua-quattro/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Aqua Quattro_in_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Quattro zijuitloop hoog 50mm, zij-ingang 40mm
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Tile: no; Build-in-Depth: 90 mm; Host: Level : Level 1
Dimensions - Outlet angle: 90 deg; Tile Thickness: 0 mm; D: 102 mm; Do1: 50 mm; Do2: 40 mm; E1: 54 mm; E2: 49 mm; NLRS_C_hoogte: 90 mm; NLRS_P_c01_diameter: 50 mm; Z1: 91 mm
Identity Data - NLRS_C_omschrijving: Aqua Quattro - Brushed Stainless Steel
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Tile Thickness Calculated: 0 mm; Build_in_depth_calculated: 90 mm; Family: NLRS_PF_52_UN_Aqua Quattro_in_uitloop_Easydrain: Aqua Quattro zijuitloop hoog 50mm, zij-ingang 40mm; Family and Type: NLRS_PF_52_UN_Aqua Quattro_in_uitloop_Easydrain: Aqua Quattro zijuitloop hoog 50mm, zij-ingang 40mm; Grate thickness: 11 mm; H_Siphon: 90 mm; Inlet Depth: 41 mm; Inlet Length: 91 mm; offset siphon: -11 mm; Outlet depth: 36 mm; R: 51 mm; ro: 25 mm; Siphon Height: 90 mm; Type: NLRS_PF_52_UN_Aqua Quattro_in_uitloop_Easydrain: Aqua Quattro zijuitloop hoog 50mm, zij-ingang 40mm; Type Id: NLRS_PF_52_UN_Aqua Quattro_in_uitloop_Easydrain: Aqua Quattro zijuitloop hoog 50mm, zij-ingang 40mm; Waterseal: 50 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Aqua Quattro_in_uitloop_Easydrain:Aqua Quattro zijuitloop hoog 50mm, zij-ingang 40mm:...) | 10x10 | 15x15 | Area (m2) | NLRS_C_breedte (mm) = NLRS_C_lengte (mm) | Volume (m3) | Design Option | Mark | NLRS_C_code_product
3061527 | yes | no | 0.0122 | 100 | 0.00011 | Main Model | 1491 | AquaW10x10-MSI2
3061531 | yes | no | 0.0122 | 100 | 0.00011 |  | 1495 | AquaW10x10-MSI2
3061599 | no | yes | 0.024528 | 146 | 0.000234476 | Main Model | 1505 | AquaW15x15-MSI2
3061603 | no | yes | 0.024528 | 146 | 0.000234476 | Main Model | 1509 | AquaW15x15-MSI2
3065103 | yes | no | 0.0122 | 100 | 0.00011 | Main Model | 1769 | AquaW10x10-MSI2
3065107 | yes | no | 0.0122 | 100 | 0.00011 | Main Model | 1773 | AquaW10x10-MSI2
3065117 | no | yes | 0.024528 | 146 | 0.000234476 | Main Model | 1783 | AquaW15x15-MSI2
3065121 | no | yes | 0.024528 | 146 | 0.000234476 | Main Model | 1787 | AquaW15x15-MSI2
3083605 | yes | no | 0.0122 | 100 | 0.00011 |  | 2194 | AquaW10x10-MSI2
3083609 | yes | no | 0.0122 | 100 | 0.00011 | Main Model | 2198 | AquaW10x10-MSI2
3083619 | no | yes | 0.024528 | 146 | 0.000234476 |  | 2208 | AquaW15x15-MSI2
3083623 | no | yes | 0.024528 | 146 | 0.000234476 | Main Model | 2212 | AquaW15x15-MSI2

# IfcFlowTerminal: Aqua Round Horizontal Outlet Low 40mm (6)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Aqua Round; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Aqua Round Horizontal Outlet Low 40mm; URL: https://www.easydrain.nl/doucheputten/aqua-round/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Aqua Round_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Round Horizontal Outlet Low 40mm
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Build-in-Depth: 59 mm; Host: Level : Level 1
Dimensions - Outlet angle: 90 deg; Tile Thickness: 0 mm; D: 102 mm; Do: 40 mm; E: 20 mm; NLRS_C_hoogte: 59 mm; NLRS_P_c01_diameter: 40 mm; Z1: 91 mm
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Tile Thickness Calculated: 0 mm; Build_in_depth_calculated: 59 mm; Family: NLRS_PF_52_UN_Aqua Round_uitloop_Easydrain: Aqua Round Horizontal Outlet Low 40mm; Family and Type: NLRS_PF_52_UN_Aqua Round_uitloop_Easydrain: Aqua Round Horizontal Outlet Low 40mm; H_Siphon: 54 mm; Outlet depth: 39 mm; R: 51 mm; ro: 20 mm; Siphon Height: 59 mm; Type: NLRS_PF_52_UN_Aqua Round_uitloop_Easydrain: Aqua Round Horizontal Outlet Low 40mm; Type Id: NLRS_PF_52_UN_Aqua Round_uitloop_Easydrain: Aqua Round Horizontal Outlet Low 40mm; Waterseal: 30 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Aqua Round_uitloop_Easydrain:Aqua Round Horizontal Outlet Low 40mm:...) | Diameter 100mm | Diameter 146mm | NLRS_C_breedte (mm) = NLRS_C_lengte (mm) | Volume (m3) | Mark | NLRS_C_code_product | NLRS_C_omschrijving | Grate thickness (mm) | offset siphon (mm)
3061633 | yes | no | 100 | 0.0000846495 | 1511 | AquaW-RDx10-MSI6 | Aqua Round 100mm | 11 | -11
3062431 | no | yes | 146 | 0.000281568 | 1525 | AquaW-RDx15-MSI6 | Aqua Round 146mm | 18 | -18
3065123 | yes | no | 100 | 0.0000846495 | 1789 | AquaW-RDx10-MSI6 | Aqua Round 100mm | 11 | -11
3065137 | no | yes | 146 | 0.000281568 | 1803 | AquaW-RDx15-MSI6 | Aqua Round 146mm | 18 | -18
3083625 | yes | no | 100 | 0.0000846495 | 2214 | AquaW-RDx10-MSI6 | Aqua Round 100mm | 11 | -11
3083639 | no | yes | 146 | 0.000281568 | 2228 | AquaW-RDx15-MSI6 | Aqua Round 146mm | 18 | -18

# IfcFlowTerminal: Aqua Round Horizontal outlet Low 50mm (6)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
