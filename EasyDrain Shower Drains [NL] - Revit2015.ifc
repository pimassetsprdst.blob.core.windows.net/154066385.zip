Properties of the parts of a building model (IFC2X3), part 3 of 9

# IfcFlowTerminal: Aqua Round Horizontal outlet Low 50mm (6)
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot verticale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Aqua Round; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Aqua Round Horizontal outlet Low 50mm; URL: https://www.easydrain.nl/doucheputten/aqua-round/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Aqua Round_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Round Horizontal outlet Low 50mm
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Build-in-Depth: 59 mm; Host: Level : Level 1
Dimensions - Outlet angle: 90 deg; Tile Thickness: 0 mm; D: 102 mm; Do: 50 mm; E: 25 mm; NLRS_C_hoogte: 59 mm; NLRS_P_c01_diameter: 50 mm; Z1: 91 mm
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Tile Thickness Calculated: 0 mm; Build_in_depth_calculated: 59 mm; Family: NLRS_PF_52_UN_Aqua Round_uitloop_Easydrain: Aqua Round Horizontal outlet Low 50mm; Family and Type: NLRS_PF_52_UN_Aqua Round_uitloop_Easydrain: Aqua Round Horizontal outlet Low 50mm; H_Siphon: 59 mm; Outlet depth: 34 mm; R: 51 mm; ro: 25 mm; Siphon Height: 59 mm; Type: NLRS_PF_52_UN_Aqua Round_uitloop_Easydrain: Aqua Round Horizontal outlet Low 50mm; Type Id: NLRS_PF_52_UN_Aqua Round_uitloop_Easydrain: Aqua Round Horizontal outlet Low 50mm; Waterseal: 30 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Aqua Round_uitloop_Easydrain:Aqua Round Horizontal outlet Low 50mm:...) | Diameter 100mm | Diameter 146mm | NLRS_C_breedte (mm) = NLRS_C_lengte (mm) | Volume (m3) | Mark | NLRS_C_code_product | NLRS_C_omschrijving | Grate thickness (mm) | offset siphon (mm)
3061927 | yes | no | 100 | 0.0000846495 | 1513 | AquaW-RDx10-MSI | Aqua Round 100mm | 11 | -11 | Identity Data - Design Option: Main Model
3062433 | no | yes | 146 | 0.000281568 | 1527 | AquaW-RDx15-MSI | Aqua Round 146mm | 18 | -18
3065125 | yes | no | 100 | 0.0000846495 | 1791 | AquaW-RDx10-MSI | Aqua Round 100mm | 11 | -11
3065139 | no | yes | 146 | 0.000281568 | 1805 | AquaW-RDx15-MSI | Aqua Round 146mm | 18 | -18 | Identity Data - Design Option: Main Model
3083627 | yes | no | 100 | 0.0000846495 | 2216 | AquaW-RDx10-MSI | Aqua Round 100mm | 11 | -11
3083641 | no | yes | 146 | 0.000281568 | 2230 | AquaW-RDx15-MSI | Aqua Round 146mm | 18 | -18

# IfcFlowTerminal: Aqua Round Horizontal outlet high 50mm (6)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot verticale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Aqua Round; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Aqua Round Horizontal outlet high 50mm; URL: https://www.easydrain.nl/doucheputten/aqua-round/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Aqua Round_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Round Horizontal outlet high 50mm
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Build-in-Depth: 59 mm; Host: Level : Level 1
Dimensions - Outlet angle: 90 deg; Tile Thickness: 0 mm; D: 102 mm; Do: 50 mm; E: 54 mm; NLRS_C_hoogte: 59 mm; NLRS_P_c01_diameter: 50 mm; Z1: 91 mm
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Tile Thickness Calculated: 0 mm; Build_in_depth_calculated: 59 mm; Family: NLRS_PF_52_UN_Aqua Round_uitloop_Easydrain: Aqua Round Horizontal outlet high 50mm; Family and Type: NLRS_PF_52_UN_Aqua Round_uitloop_Easydrain: Aqua Round Horizontal outlet high 50mm; H_Siphon: 90 mm; Outlet depth: 36 mm; R: 51 mm; ro: 25 mm; Siphon Height: 90 mm; Type: NLRS_PF_52_UN_Aqua Round_uitloop_Easydrain: Aqua Round Horizontal outlet high 50mm; Type Id: NLRS_PF_52_UN_Aqua Round_uitloop_Easydrain: Aqua Round Horizontal outlet high 50mm; Waterseal: 50 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Aqua Round_uitloop_Easydrain:Aqua Round Horizontal outlet high 50mm:...) | Diameter 100mm | Diameter 146mm | NLRS_C_breedte (mm) = NLRS_C_lengte (mm) | Volume (m3) | Design Option | Mark | NLRS_C_code_product | NLRS_C_omschrijving | Grate thickness (mm) | offset siphon (mm)
3062002 | yes | no | 100 | 0.0000846495 | Main Model | 1515 | AquaW-RDx10-MSI1 | Aqua Round 100mm | 11 | -11
3062435 | no | yes | 146 | 0.000281568 |  | 1529 | AquaW-RDx15-MSI1 | Aqua Round 146mm | 18 | -18
3065127 | yes | no | 100 | 0.0000846495 | Main Model | 1793 | AquaW-RDx10-MSI1 | Aqua Round 100mm | 11 | -11
3065141 | no | yes | 146 | 0.000281568 |  | 1807 | AquaW-RDx15-MSI1 | Aqua Round 146mm | 18 | -18
3083629 | yes | no | 100 | 0.0000846495 | Main Model | 2218 | AquaW-RDx10-MSI1 | Aqua Round 100mm | 11 | -11
3083643 | no | yes | 146 | 0.000281568 | Main Model | 2232 | AquaW-RDx15-MSI1 | Aqua Round 146mm | 18 | -18

# IfcFlowTerminal: Aqua Round Vertical Outlet 50mm (6)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot verticale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Aqua Round; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Aqua Round Vertical Outlet 50mm; URL: https://www.easydrain.nl/doucheputten/aqua-round/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Aqua Round_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Round Vertical Outlet 50mm
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Build-in-Depth: 59 mm; Host: Level : Level 1
Dimensions - E: 0 mm; Outlet angle: 180 deg; Tile Thickness: 0 mm; D: 102 mm; Do: 50 mm; NLRS_C_hoogte: 59 mm; NLRS_P_c01_diameter: 50 mm; Z1: 40 mm
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Tile Thickness Calculated: 0 mm; Build_in_depth_calculated: 59 mm; Family: NLRS_PF_52_UN_Aqua Round_uitloop_Easydrain: Aqua Round Vertical Outlet 50mm; Family and Type: NLRS_PF_52_UN_Aqua Round_uitloop_Easydrain: Aqua Round Vertical Outlet 50mm; H_Siphon: 90 mm; Outlet depth: 90 mm; R: 51 mm; ro: 25 mm; Siphon Height: 90 mm; Type: NLRS_PF_52_UN_Aqua Round_uitloop_Easydrain: Aqua Round Vertical Outlet 50mm; Type Id: NLRS_PF_52_UN_Aqua Round_uitloop_Easydrain: Aqua Round Vertical Outlet 50mm; Waterseal: 35 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Aqua Round_uitloop_Easydrain:Aqua Round Vertical Outlet 50mm:...) | Diameter 100mm | Diameter 146mm | NLRS_C_breedte (mm) = NLRS_C_lengte (mm) | Volume (m3) | Mark | NLRS_C_code_product | NLRS_C_omschrijving | Grate thickness (mm) | offset siphon (mm)
3062069 | yes | no | 100 | 0.0000846495 | 1517 | AquaW-RDx10-MSI3 | Aqua Round 100mm | 11 | -11
3062437 | no | yes | 146 | 0.000281568 | 1531 | AquaW-RDx15-MSI3 | Aqua Round 146mm | 18 | -18 | Identity Data - Design Option: Main Model
3065129 | yes | no | 100 | 0.0000846495 | 1795 | AquaW-RDx10-MSI3 | Aqua Round 100mm | 11 | -11
3065143 | no | yes | 146 | 0.000281568 | 1809 | AquaW-RDx15-MSI3 | Aqua Round 146mm | 18 | -18 | Identity Data - Design Option: Main Model
3083631 | yes | no | 100 | 0.0000846495 | 2220 | AquaW-RDx10-MSI3 | Aqua Round 100mm | 11 | -11
3083645 | no | yes | 146 | 0.000281568 | 2234 | AquaW-RDx15-MSI3 | Aqua Round 146mm | 18 | -18

# IfcFlowTerminal: Aqua Round onderuitloop 50mm, zij-ingang 40mm (6)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot verticale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Aqua Round; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Aqua Round onderuitloop 50mm, zij-ingang 40mm; URL: https://www.easydrain.nl/doucheputten/aqua-round/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Aqua Round_in_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Round onderuitloop 50mm, zij-ingang 40mm
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Build-in-Depth: 90 mm; Host: Level : Level 1
Dimensions - Outlet angle: 180 deg; E1: 0 mm; Tile Thickness: 0 mm; D: 102 mm; Do1: 50 mm; Do2: 40 mm; E2: 49 mm; NLRS_C_hoogte: 90 mm; NLRS_P_c01_diameter: 50 mm; Z1: 40 mm
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Tile Thickness Calculated: 0 mm; Build_in_depth_calculated: 90 mm; Family: NLRS_PF_52_UN_Aqua Round_in_uitloop_Easydrain: Aqua Round onderuitloop 50mm, zij-ingang 40mm; Family and Type: NLRS_PF_52_UN_Aqua Round_in_uitloop_Easydrain: Aqua Round onderuitloop 50mm, zij-ingang 40mm; H_Siphon: 90 mm; Inlet Depth: 41 mm; Inlet Length: 91 mm; Outlet depth: 90 mm; R: 51 mm; ro: 25 mm; Siphon Height: 90 mm; Type: NLRS_PF_52_UN_Aqua Round_in_uitloop_Easydrain: Aqua Round onderuitloop 50mm, zij-ingang 40mm; Type Id: NLRS_PF_52_UN_Aqua Round_in_uitloop_Easydrain: Aqua Round onderuitloop 50mm, zij-ingang 40mm; Waterseal: 35 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Aqua Round_in_uitloop_Easydrain:Aqua Round onderuitloop 50mm, zij-ingang 40mm:...) | Diameter 100mm | Diameter 146mm | NLRS_C_breedte (mm) = NLRS_C_lengte (mm) | Volume (m3) | Mark | NLRS_C_code_product | NLRS_C_omschrijving | Grate thickness (mm) | offset siphon (mm)
3062379 | yes | no | 100 | 0.0000846495 | 1523 | AquaW-RDx10-MSI4 | Aqua Round 100mm | 11 | -11
3062443 | no | yes | 146 | 0.000281568 | 1537 | AquaW-RDx15-MSI4 | Aqua Round 146mm | 18 | -18 | Identity Data - Design Option: Main Model
3065135 | yes | no | 100 | 0.0000846495 | 1801 | AquaW-RDx10-MSI4 | Aqua Round 100mm | 11 | -11
3065149 | no | yes | 146 | 0.000281568 | 1815 | AquaW-RDx15-MSI4 | Aqua Round 146mm | 18 | -18
3083637 | yes | no | 100 | 0.0000846495 | 2226 | AquaW-RDx10-MSI4 | Aqua Round 100mm | 11 | -11
3083651 | no | yes | 146 | 0.000281568 | 2240 | AquaW-RDx15-MSI4 | Aqua Round 146mm | 18 | -18 | Identity Data - Design Option: Main Model

# IfcFlowTerminal: Aqua Round onderuitloop 50mm, zij-ingang 50mm (6)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot verticale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Aqua Round; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Aqua Round onderuitloop 50mm, zij-ingang 50mm; URL: https://www.easydrain.nl/doucheputten/aqua-round/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Aqua Round_in_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Round onderuitloop 50mm, zij-ingang 50mm
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Build-in-Depth: 90 mm; Host: Level : Level 1
Dimensions - Outlet angle: 180 deg; E1: 0 mm; Tile Thickness: 0 mm; D: 102 mm; Do1: 50 mm; Do2: 50 mm; E2: 54 mm; NLRS_C_hoogte: 90 mm; NLRS_P_c01_diameter: 50 mm; Z1: 40 mm
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Tile Thickness Calculated: 0 mm; Build_in_depth_calculated: 90 mm; Family: NLRS_PF_52_UN_Aqua Round_in_uitloop_Easydrain: Aqua Round onderuitloop 50mm, zij-ingang 50mm; Family and Type: NLRS_PF_52_UN_Aqua Round_in_uitloop_Easydrain: Aqua Round onderuitloop 50mm, zij-ingang 50mm; H_Siphon: 90 mm; Inlet Depth: 36 mm; Inlet Length: 91 mm; Outlet depth: 90 mm; R: 51 mm; ro: 25 mm; Siphon Height: 90 mm; Type: NLRS_PF_52_UN_Aqua Round_in_uitloop_Easydrain: Aqua Round onderuitloop 50mm, zij-ingang 50mm; Type Id: NLRS_PF_52_UN_Aqua Round_in_uitloop_Easydrain: Aqua Round onderuitloop 50mm, zij-ingang 50mm; Waterseal: 35 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Aqua Round_in_uitloop_Easydrain:Aqua Round onderuitloop 50mm, zij-ingang 50mm:...) | Diameter 100mm | Diameter 146mm | NLRS_C_breedte (mm) = NLRS_C_lengte (mm) | Volume (m3) | Mark | NLRS_C_code_product | NLRS_C_omschrijving | Grate thickness (mm) | offset siphon (mm) | Design Option
3062251 | yes | no | 100 | 0.0000846495 | 1521 | AquaW-RDx10-MSI5 | Aqua Round 100mm | 11 | -11
3062441 | no | yes | 146 | 0.000281568 | 1535 | AquaW-RDx15-MSI5 | Aqua Round 146mm | 18 | -18 | Main Model
3065133 | yes | no | 100 | 0.0000846495 | 1799 | AquaW-RDx10-MSI5 | Aqua Round 100mm | 11 | -11
3065147 | no | yes | 146 | 0.000281568 | 1813 | AquaW-RDx15-MSI5 | Aqua Round 146mm | 18 | -18 | Main Model
3083635 | yes | no | 100 | 0.0000846495 | 2224 | AquaW-RDx10-MSI5 | Aqua Round 100mm | 11 | -11 | Main Model
3083649 | no | yes | 146 | 0.000281568 | 2238 | AquaW-RDx15-MSI5 | Aqua Round 146mm | 18 | -18 | Main Model

# IfcFlowTerminal: Aqua Round zijuitloop hoog 50mm, zij-ingang 40mm (6)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Aqua Round; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Aqua Round zijuitloop hoog 50mm, zij-ingang 40mm; URL: https://www.easydrain.nl/doucheputten/aqua-round/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Aqua Round_in_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Round zijuitloop hoog 50mm, zij-ingang 40mm
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Build-in-Depth: 90 mm; Host: Level : Level 1
Dimensions - Outlet angle: 90 deg; Tile Thickness: 0 mm; D: 102 mm; Do1: 50 mm; Do2: 40 mm; E1: 54 mm; E2: 49 mm; NLRS_C_hoogte: 90 mm; NLRS_P_c01_diameter: 50 mm; Z1: 91 mm
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Tile Thickness Calculated: 0 mm; Build_in_depth_calculated: 90 mm; Family: NLRS_PF_52_UN_Aqua Round_in_uitloop_Easydrain: Aqua Round zijuitloop hoog 50mm, zij-ingang 40mm; Family and Type: NLRS_PF_52_UN_Aqua Round_in_uitloop_Easydrain: Aqua Round zijuitloop hoog 50mm, zij-ingang 40mm; H_Siphon: 90 mm; Inlet Depth: 41 mm; Inlet Length: 91 mm; Outlet depth: 36 mm; R: 51 mm; ro: 25 mm; Siphon Height: 90 mm; Type: NLRS_PF_52_UN_Aqua Round_in_uitloop_Easydrain: Aqua Round zijuitloop hoog 50mm, zij-ingang 40mm; Type Id: NLRS_PF_52_UN_Aqua Round_in_uitloop_Easydrain: Aqua Round zijuitloop hoog 50mm, zij-ingang 40mm; Waterseal: 50 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Aqua Round_in_uitloop_Easydrain:Aqua Round zijuitloop hoog 50mm, zij-ingang 40mm:...) | Diameter 100mm | Diameter 146mm | NLRS_C_breedte (mm) = NLRS_C_lengte (mm) | Volume (m3) | Mark | NLRS_C_code_product | NLRS_C_omschrijving | Grate thickness (mm) | offset siphon (mm)
3062151 | yes | no | 100 | 0.0000846495 | 1519 | AquaW-RDx10-MSI2 | Aqua Round 100mm | 11 | -11 | Identity Data - Design Option: Main Model
3062439 | no | yes | 146 | 0.000281568 | 1533 | AquaW-RDx15-MSI2 | Aqua Round 146mm | 18 | -18
3065131 | yes | no | 100 | 0.0000846495 | 1797 | AquaW-RDx10-MSI2 | Aqua Round 100mm | 11 | -11
3065145 | no | yes | 146 | 0.000281568 | 1811 | AquaW-RDx15-MSI2 | Aqua Round 146mm | 18 | -18
3083633 | yes | no | 100 | 0.0000846495 | 2222 | AquaW-RDx10-MSI2 | Aqua Round 100mm | 11 | -11
3083647 | no | yes | 146 | 0.000281568 | 2236 | AquaW-RDx15-MSI2 | Aqua Round 146mm | 18 | -18 | Identity Data - Design Option: Main Model

# IfcFlowTerminal: Black Glass 10x10 (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_52_WPS_ EasyDrain, NLRS_o_Glas_zwart, Roestvrijstaal,geborsteld
Type - Dimensions - Grate Length: 100 mm; Grate Width: 100 mm
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Aqua Jewels Quatro; Manufacturer: Easy Sanitary Solutions; Model: Aqua Jewels Quatro; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Black Glass 10x10; URL: https://www.easydrain.nl/doucheputten/aqua-jewels-quattro/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: NLRS_o_Glas_zwart
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Black Glass 10x10
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm; WPS: yes; Host: Level : Level 1; Tile Thickness: 5 mm
Dimensions - Flange length: 160 mm; Flange width: 160 mm; Grate Depth: 20 mm; NLRS_C_breedte: 100 mm; NLRS_C_lengte: 100 mm; Volume: 0.0005105 m3
Identity Data - NLRS_C_code_product: AJQ-10X10-GS; NLRS_C_omschrijving: Aqua Jewels Quatro - Black Glass
Other - offset_length: 0 mm; offset_width: 0 mm; Tile: yes; Family: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Black Glass 10x10; Family and Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Black Glass 10x10; s: 5 mm; Tile_Thickness_calculated: 5 mm; Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Black Glass 10x10; Type Id: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Black Glass 10x10; WPS Length: 330 mm
Phasing - Phase Created: New Construction
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain:Black Glass 10x10:...) | Build-in-Depth (mm) = NLRS_C_hoogte (mm) = Build_in_depth_calculated (mm) | Design Option | Mark
3053128 | 59 | Main Model | 1072
3053453 | 90 | Main Model | 1171
3060101 | 59 | Main Model | 1343
3060146 | 90 |  | 1388
3064961 | 59 |  | 1627
3065006 | 90 |  | 1672
3083463 | 59 | Main Model | 2052
3083508 | 90 | Main Model | 2097

# IfcFlowTerminal: Black Glass 15x15 (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_52_WPS_ EasyDrain, NLRS_o_Glas_zwart, Roestvrijstaal,geborsteld
Type - Dimensions - Grate Length: 150 mm; Grate Width: 150 mm
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Aqua Jewels Quatro; Manufacturer: Easy Sanitary Solutions; Model: Aqua Jewels Quatro; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Black Glass 15x15; URL: https://www.easydrain.nl/doucheputten/aqua-jewels-quattro/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: NLRS_o_Glas_zwart
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Black Glass 15x15
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm; WPS: yes; Host: Level : Level 1; Tile Thickness: 5 mm
Dimensions - Flange length: 210 mm; Flange width: 210 mm; Grate Depth: 20 mm; NLRS_C_breedte: 150 mm; NLRS_C_lengte: 150 mm; Volume: 0.000855 m3
Identity Data - NLRS_C_code_product: AJQ-15X15-GS; NLRS_C_omschrijving: Aqua Jewels Quatro - Black Glass
Other - Tile: yes; Family: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Black Glass 15x15; Family and Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Black Glass 15x15; offset_length: 5 mm; offset_width: 10 mm; s: 5 mm; Tile_Thickness_calculated: 5 mm; Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Black Glass 15x15; Type Id: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Black Glass 15x15; WPS Length: 330 mm
Phasing - Phase Created: New Construction
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain:Black Glass 15x15:...) | Build-in-Depth (mm) = NLRS_C_hoogte (mm) = Build_in_depth_calculated (mm) | Mark
3053131 | 59 | 1075
3053456 | 90 | 1174
3060104 | 59 | 1346 | Identity Data - Design Option: Main Model
3060149 | 90 | 1391 | Identity Data - Design Option: Main Model
3064964 | 59 | 1630 | Identity Data - Design Option: Main Model
3065009 | 90 | 1675 | Identity Data - Design Option: Main Model
3083466 | 59 | 2055
3083511 | 90 | 2100

# IfcFlowTerminal: Black Glass 20x20 (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_52_WPS_ EasyDrain, NLRS_o_Glas_zwart, Roestvrijstaal,geborsteld
Type - Dimensions - Grate Length: 200 mm; Grate Width: 200 mm
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Aqua Jewels Quatro; Manufacturer: Easy Sanitary Solutions; Model: Aqua Jewels Quatro; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Black Glass 20x20; URL: https://www.easydrain.nl/doucheputten/aqua-jewels-quattro/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: NLRS_o_Glas_zwart
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Black Glass 20x20
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm; WPS: yes; Host: Level : Level 1; Tile Thickness: 5 mm
Dimensions - Flange length: 260 mm; Flange width: 260 mm; Grate Depth: 20 mm; NLRS_C_breedte: 200 mm; NLRS_C_lengte: 200 mm; Volume: 0.0013345 m3
Identity Data - NLRS_C_code_product: AJQ-20X20-GS; NLRS_C_omschrijving: Aqua Jewels Quatro - Black Glass
Other - Tile: yes; Family: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Black Glass 20x20; Family and Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Black Glass 20x20; offset_length: 5 mm; offset_width: 10 mm; s: 5 mm; Tile_Thickness_calculated: 5 mm; Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Black Glass 20x20; Type Id: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Black Glass 20x20; WPS Length: 330 mm
Phasing - Phase Created: New Construction
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain:Black Glass 20x20:...) | Build-in-Depth (mm) = NLRS_C_hoogte (mm) = Build_in_depth_calculated (mm) | Design Option | Mark
3053134 | 59 | Main Model | 1078
3053459 | 90 |  | 1177
3060107 | 59 | Main Model | 1349
3060152 | 90 | Main Model | 1394
3064967 | 59 | Main Model | 1633
3065012 | 90 |  | 1678
3083469 | 59 |  | 2058
3083514 | 90 | Main Model | 2103

# IfcFlowTerminal: Brilliant onderuitloop 50mm (4)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, Rubber, Butyl
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot verticale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Aqua Brilliant; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Brilliant onderuitloop 50mm; URL: http://www.easydrain.nl/nl/easy-drain/aqua/aqua-brilliant.html
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Aqua Brilliant_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Brilliant onderuitloop 50mm
Constraints - Offset: 0 mm; Level: Level: Level 1; Build-in-Depth: 65 mm; Host: Level : Level 1
Dimensions - Angle: 270 deg; D: 146 mm; Do: 50 mm; E: 61 mm; NLRS_C_breedte: 146 mm; NLRS_C_hoogte: 65 mm; NLRS_C_lengte: 146 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.00137385 m3; Z1: 125 mm
Identity Data - NLRS_C_code_product: AquaBW-15x15; NLRS_C_omschrijving: Aqua Brilliant
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Family: NLRS_PF_52_UN_Aqua Brilliant_Easydrain: Brilliant onderuitloop 50mm; Family and Type: NLRS_PF_52_UN_Aqua Brilliant_Easydrain: Brilliant onderuitloop 50mm; Grate Thickness: 9 mm; Height_calculated: 65 mm; horizontal: no; R: 73 mm; ro: 25 mm; Siphon Height: 58.5 mm; Type: NLRS_PF_52_UN_Aqua Brilliant_Easydrain: Brilliant onderuitloop 50mm; Type Id: NLRS_PF_52_UN_Aqua Brilliant_Easydrain: Brilliant onderuitloop 50mm; vertical: yes; Waterseal: 50 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Aqua Brilliant_Easydrain:Brilliant onderuitloop 50mm:...) | WPS | Mark
3063278 | no | 1554
3065166 | no | 1832
3083216 | no | 1971 | Identity Data - Design Option: Main Model
3083668 | yes | 2257

# IfcFlowTerminal: Brilliant zijuitloop laag 50mm (4)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, Rubber, Butyl
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Aqua Brilliant; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Brilliant zijuitloop laag 50mm; URL: http://www.easydrain.nl/nl/easy-drain/aqua/aqua-brilliant.html
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Aqua Brilliant_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Brilliant zijuitloop laag 50mm
Constraints - Offset: 0 mm; Level: Level: Level 1; Build-in-Depth: 65 mm; Host: Level : Level 1
Dimensions - Angle: 0 deg; D: 146 mm; Do: 50 mm; E: 27.5 mm; NLRS_C_breedte: 146 mm; NLRS_C_hoogte: 65 mm; NLRS_C_lengte: 146 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.00133962 m3; Z1: 125 mm
Identity Data - NLRS_C_code_product: AquaBW-15x15; NLRS_C_omschrijving: Aqua Brilliant
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Family: NLRS_PF_52_UN_Aqua Brilliant_Easydrain: Brilliant zijuitloop laag 50mm; Family and Type: NLRS_PF_52_UN_Aqua Brilliant_Easydrain: Brilliant zijuitloop laag 50mm; Grate Thickness: 9 mm; Height_calculated: 65 mm; horizontal: yes; R: 73 mm; ro: 25 mm; Siphon Height: 58.5 mm; Type: NLRS_PF_52_UN_Aqua Brilliant_Easydrain: Brilliant zijuitloop laag 50mm; Type Id: NLRS_PF_52_UN_Aqua Brilliant_Easydrain: Brilliant zijuitloop laag 50mm; vertical: no; Waterseal: 50 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Aqua Brilliant_Easydrain:Brilliant zijuitloop laag 50mm:...) | WPS | Mark
3063088 | no | 1553 | Identity Data - Design Option: Main Model
3065165 | no | 1831
3083215 | no | 1970 | Identity Data - Design Option: Main Model
3083667 | yes | 2256

# IfcFlowTerminal: Compact (16)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - Dimensions - NLRS_P_c01_diameter: 50 mm
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitloop; Manufacturer: Easy Sanitary Solutions; Model: Aqua Compact; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_C_omschrijving: Aqua Compact; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Comments: Complete set incl. rooster. Met waterslot 35mm; Type Name: Compact; URL: http://www.easydrain.nl/nl/aqua-compact.html
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Aqua Compact_Easydrain; Grate Width: 140 mm
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Host: Level : Level 1
Dimensions - NLRS_C_breedte: 146 mm; NLRS_C_hoogte: 60 mm; NLRS_C_lengte: 146 mm
Mechanical - System Classification: Sanitary
Other - Family: NLRS_PF_52_UN_Aqua Compact_Easydrain: Compact; Family and Type: NLRS_PF_52_UN_Aqua Compact_Easydrain: Compact; Flange Width: 186 mm; Type: NLRS_PF_52_UN_Aqua Compact_Easydrain: Compact; Type Id: NLRS_PF_52_UN_Aqua Compact_Easydrain: Compact
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Aqua Compact_Easydrain:Compact:...) | Waterseal 30mm | Waterseal 50mm | Flange | Volume (m3) | Mark | NLRS_C_code_product | Connector position (mm) | Do1 (mm) | Outlet connection length (mm) | Outlet Length (mm) | Outlet Position (mm) | Siphon Height (mm)
3063368 | yes | no | no | 0.00124638 | 1555 | AQUACOM-15x15 | 35 | 40 | 57.5 | 188 | 40 | 60
3063654 | yes | no | yes | 0.00131557 | 1556 | AQUACOM-15x15-FL | 35 | 40 | 57.5 | 188 | 40 | 60
3063690 | no | yes | no | 0.0013618 | 1557 | AQUACOM50-15x15 | 48 | 50 | 73 | 73 | 48 | 73
3063691 | no | yes | yes | 0.00143099 | 1558 | AQUACOM50-15x15-FL | 48 | 50 | 73 | 73 | 48 | 73 | Identity Data - Design Option: Main Model
3065167 | yes | no | no | 0.00124638 | 1833 | AQUACOM-15x15 | 35 | 40 | 57.5 | 188 | 40 | 60
3065168 | yes | no | yes | 0.00131557 | 1834 | AQUACOM-15x15-FL | 35 | 40 | 57.5 | 188 | 40 | 60 | Identity Data - Design Option: Main Model
3065169 | no | yes | no | 0.0013618 | 1835 | AQUACOM50-15x15 | 48 | 50 | 73 | 73 | 48 | 73 | Identity Data - Design Option: Main Model
3065170 | no | yes | yes | 0.00143099 | 1836 | AQUACOM50-15x15-FL | 48 | 50 | 73 | 73 | 48 | 73
3083217 | yes | no | no | 0.00124638 | 1972 | AQUACOM-15x15 | 35 | 40 | 57.5 | 188 | 40 | 60
3083218 | yes | no | yes | 0.00131557 | 1973 | AQUACOM-15x15-FL | 35 | 40 | 57.5 | 188 | 40 | 60 | Identity Data - Design Option: Main Model
3083219 | no | yes | no | 0.0013618 | 1974 | AQUACOM50-15x15 | 48 | 50 | 73 | 73 | 48 | 73 | Identity Data - Design Option: Main Model
3083220 | no | yes | yes | 0.00143099 | 1975 | AQUACOM50-15x15-FL | 48 | 50 | 73 | 73 | 48 | 73 | Identity Data - Design Option: Main Model
3083669 | yes | no | no | 0.00124638 | 2258 | AQUACOM-15x15 | 35 | 40 | 57.5 | 188 | 40 | 60
3083670 | yes | no | yes | 0.00131557 | 2259 | AQUACOM-15x15-FL | 35 | 40 | 57.5 | 188 | 40 | 60
3083671 | no | yes | no | 0.0013618 | 2260 | AQUACOM50-15x15 | 48 | 50 | 73 | 73 | 48 | 73
3083672 | no | yes | yes | 0.00143099 | 2261 | AQUACOM50-15x15-FL | 48 | 50 | 73 | 73 | 48 | 73

# IfcFlowTerminal: Compact (12)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Compact; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Compact; URL: https://www.easydrain.nl/douchegoten/compact/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Wall profile: no; Flange: no; Family Name: NLRS_PF_52_UN_Compact_Easydrain; WPS seal: no
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact
Constraints - Offset: 0 mm; Level: Level: Level 1; Grate Length: 500 mm; Host: Level : Level 1
Dimensions - NLRS_C_breedte: 60 mm; NLRS_C_lengte: 500 mm
Identity Data - NLRS_C_omschrijving: Compact
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Family: NLRS_PF_52_UN_Compact_Easydrain: Compact; Family and Type: NLRS_PF_52_UN_Compact_Easydrain: Compact; Flange width: 100 mm; Length Calculated: 500 mm; min_length: 500 mm; s: 1 mm; Type: NLRS_PF_52_UN_Compact_Easydrain: Compact; Type Id: NLRS_PF_52_UN_Compact_Easydrain: Compact
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Compact_Easydrain:Compact:...) | Zero = Closed cover | Waterseal 30mm | Waterseal 50mm = Adjustable Legs | Classic | NLRS_C_hoogte (mm) = Build-in-Depth (mm) | NLRS_P_c01_diameter (mm) | Volume (m3) | Mark | NLRS_C_code_product | product_index | connector_position (mm) | max_length (mm) | ro (mm) | Design Option
3083349 | no | yes | no | yes | 61 | 40 | 0.00118818 | 2012 | EDCOM 500 -30 | 1 | 38 | 1200 | 20
3083350 | yes | yes | no | no | 61 | 40 | 0.0011583 | 2013 | EDCOMZ 500 -30 | 9 | 38 | 1200 | 20 | Main Model
3083351 | no | no | yes | yes | 81 | 50 | 0.00165083 | 2014 | EDCOM 500 -50 | 17 | 48 | 2000 | 25 | Main Model
3083352 | yes | no | yes | no | 81 | 50 | 0.00162095 | 2015 | EDCOMZ 500 -50 | 33 | 48 | 1200 | 25 | Main Model
3961698 | no | yes | no | yes | 61 | 40 | 0.00118818 | 2676 | EDCOM 500 -30 | 1 | 38 | 1200 | 20 | Main Model
3961699 | yes | yes | no | no | 61 | 40 | 0.0011583 | 2677 | EDCOMZ 500 -30 | 9 | 38 | 1200 | 20 | Main Model
3961700 | no | no | yes | yes | 81 | 50 | 0.00165083 | 2678 | EDCOM 500 -50 | 17 | 48 | 2000 | 25
3961701 | yes | no | yes | no | 81 | 50 | 0.00162095 | 2679 | EDCOMZ 500 -50 | 33 | 48 | 1200 | 25 | Main Model
3961733 | no | yes | no | yes | 61 | 40 | 0.00118818 | 2688 | EDCOM 500 -30 | 1 | 38 | 1200 | 20 | Main Model
3961734 | yes | yes | no | no | 61 | 40 | 0.0011583 | 2689 | EDCOMZ 500 -30 | 9 | 38 | 1200 | 20 | Main Model
3961735 | no | no | yes | yes | 81 | 50 | 0.00165083 | 2690 | EDCOM 500 -50 | 17 | 48 | 2000 | 25
3961736 | yes | no | yes | no | 81 | 50 | 0.00162095 | 2691 | EDCOMZ 500 -50 | 33 | 48 | 1200 | 25 | Main Model

# IfcFlowTerminal: Compact, NLRS_PF_52_UN_Showerboard Compact_Easydrain:Compact:3373956
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Showerboard Compact; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Compact; URL: http://www.easydrain.nl/nl/easy-drain/compact/compact.html
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Showerboard Compact_Easydrain; waterdicht_doek: no
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact
Constraints - Level: Level: Level 1; Offset: 0 mm; Host: Level : Level 1; Showerboard Length: 1200 mm; Showerboard Width: 1100 mm; Tile Thickness: 7 mm
Dimensions - NLRS_C_breedte: 1400 mm; NLRS_C_hoogte: 73 mm; NLRS_C_lengte: 1200 mm; NLRS_P_c01_diameter: 40 mm; Volume: 0.0800114 m3
Identity Data - Mark: 2572; NLRS_C_code_product: SBCOM-LINE-1; NLRS_C_omschrijving: Shower Board Compact (M1)
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Family: NLRS_PF_52_UN_Showerboard Compact_Easydrain: Compact; Family and Type: NLRS_PF_52_UN_Showerboard Compact_Easydrain: Compact; grate_length: 665 mm; grate_width: 60 mm; Height_wall: 56 mm; length_calculated: 1200 mm; max_length: 1200 mm; max_width: 1100 mm; min_length: 900 mm; min_width: 550 mm; offset_outlet: 25 mm; ro: 20 mm; s: 1 mm; Tile_thickness_check: 7 mm; Type: NLRS_PF_52_UN_Showerboard Compact_Easydrain: Compact; Type Id: NLRS_PF_52_UN_Showerboard Compact_Easydrain: Compact; width_calculated: 1100 mm; width_wall: 300 mm
Phasing - Phase Created: New Construction

# IfcFlowTerminal: Compact FF (16)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Compact; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Compact FF; URL: https://www.easydrain.nl/douchegoten/compact-ff/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Wall profile: no; Family Name: NLRS_PF_52_UN_Compact_Easydrain; Flange: no; WPS seal: yes
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact FF
Constraints - Level: Level: Level 1; Offset: 0 mm; Grate Length: 500 mm; Host: Level : Level 1
Dimensions - NLRS_C_breedte: 60 mm; NLRS_C_lengte: 500 mm
Identity Data - NLRS_C_omschrijving: Compact FF
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Adjustable Legs: yes; Family: NLRS_PF_52_UN_Compact_Easydrain: Compact FF; Family and Type: NLRS_PF_52_UN_Compact_Easydrain: Compact FF; Flange width: 100 mm; Length Calculated: 500 mm; min_length: 500 mm; s: 1 mm; Type: NLRS_PF_52_UN_Compact_Easydrain: Compact FF; Type Id: NLRS_PF_52_UN_Compact_Easydrain: Compact FF
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Compact_Easydrain:Compact FF:...) | Zero = Closed cover | Waterseal 30mm | Waterseal 50mm | Classic | NLRS_C_hoogte (mm) = Build-in-Depth (mm) | NLRS_P_c01_diameter (mm) | Volume (m3) | Mark | NLRS_C_code_product | connector_position (mm) | max_length (mm) | product_index | ro (mm)
3057215 | no | yes | no | yes | 61 | 40 | 0.00144825 | 1265 | EDCOMFF 500 -30 | 38 | 2000 | 41 | 20
3057258 | yes | yes | no | no | 61 | 40 | 0.00141837 | 1266 | EDCOMFFZ 500 -30 | 38 | 1200 | 57 | 20
3057371 | no | no | yes | yes | 81 | 50 | 0.00180283 | 1267 | EDCOMFF 500 -50 | 48 | 2000 | 65 | 25 | Identity Data - Design Option: Main Model
3057422 | yes | no | yes | no | 81 | 50 | 0.00177295 | 1268 | EDCOMFFZ 500 -50 | 48 | 1200 | 81 | 25 | Identity Data - Design Option: Main Model
3066581 | no | yes | no | yes | 61 | 40 | 0.00144825 | 1847 | EDCOMFF 500 -30 | 38 | 2000 | 41 | 20
3066582 | yes | yes | no | no | 61 | 40 | 0.00141837 | 1848 | EDCOMFFZ 500 -30 | 38 | 1200 | 57 | 20 | Identity Data - Design Option: Main Model
3067597 | no | no | yes | yes | 81 | 50 | 0.00180283 | 1853 | EDCOMFF 500 -50 | 48 | 2000 | 65 | 25
3067598 | yes | no | yes | no | 81 | 50 | 0.00177295 | 1854 | EDCOMFFZ 500 -50 | 48 | 1200 | 81 | 25
3083410 | no | yes | no | yes | 61 | 40 | 0.00144825 | 2026 | EDCOMFF 500 -30 | 38 | 2000 | 41 | 20
3083411 | yes | yes | no | no | 61 | 40 | 0.00141837 | 2027 | EDCOMFFZ 500 -30 | 38 | 1200 | 57 | 20
3083412 | no | no | yes | yes | 81 | 50 | 0.00180283 | 2028 | EDCOMFF 500 -50 | 48 | 2000 | 65 | 25
3083413 | yes | no | yes | no | 81 | 50 | 0.00177295 | 2029 | EDCOMFFZ 500 -50 | 48 | 1200 | 81 | 25 | Identity Data - Design Option: Main Model
3083816 | no | yes | no | yes | 61 | 40 | 0.00144825 | 2313 | EDCOMFF 500 -30 | 38 | 2000 | 41 | 20 | Identity Data - Design Option: Main Model
3083817 | yes | yes | no | no | 61 | 40 | 0.00141837 | 2314 | EDCOMFFZ 500 -30 | 38 | 1200 | 57 | 20
3083822 | no | no | yes | yes | 81 | 50 | 0.00180283 | 2319 | EDCOMFF 500 -50 | 48 | 2000 | 65 | 25
3083823 | yes | no | yes | no | 81 | 50 | 0.00177295 | 2320 | EDCOMFFZ 500 -50 | 48 | 1200 | 81 | 25

# IfcFlowTerminal: Compact FF Tile (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_n1_Asfalt_bitumen, NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Compact Tile; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Compact FF Tile; URL: https://www.easydrain.nl/douchegoten/compact-ff/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: NLRS_n1_Asfalt_bitumen
Type - Other - Category: Plumbing Fixtures; WPS seal: yes; Family Name: NLRS_PF_52_UN_Compact Tile_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact FF Tile
Constraints - Level: Level: Level 1; Offset: 0 mm; Grate Length: 500 mm; Host: Level : Level 1
Dimensions - NLRS_C_breedte: 60 mm; NLRS_C_lengte: 500 mm
Identity Data - NLRS_C_omschrijving: Compact FF Tile
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Adjustable Legs: yes; Family: NLRS_PF_52_UN_Compact Tile_Easydrain: Compact FF Tile; Family and Type: NLRS_PF_52_UN_Compact Tile_Easydrain: Compact FF Tile; Flange Width: 100 mm; Length Calculated: 500 mm; max_length: 2000 mm; s: 3 mm; Type: NLRS_PF_52_UN_Compact Tile_Easydrain: Compact FF Tile; Type Id: NLRS_PF_52_UN_Compact Tile_Easydrain: Compact FF Tile
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Compact Tile_Easydrain:Compact FF Tile:...) | Waterseal 30mm | Waterseal 50mm | NLRS_C_hoogte (mm) | NLRS_P_c01_diameter (mm) | Volume (m3) | Design Option | Mark | NLRS_C_code_product | Build-in-Depth (mm) | connector_position (mm) | product_index | ro (mm)
3057881 | yes | no | 83 | 40 | 0.00177705 | Main Model | 1269 | EDCOMTFF 500 -30 | 73 | 38 | 17 | 20
3057998 | no | yes | 103 | 50 | 0.00213159 | Main Model | 1270 | EDCOMTFF 500 -50 | 93 | 48 | 33 | 25
3067716 | yes | no | 83 | 40 | 0.00177705 |  | 1855 | EDCOMTFF 500 -30 | 73 | 38 | 17 | 20
3067757 | no | yes | 103 | 50 | 0.00213159 | Main Model | 1856 | EDCOMTFF 500 -50 | 93 | 48 | 33 | 25
3083414 | yes | no | 83 | 40 | 0.00177705 |  | 2030 | EDCOMTFF 500 -30 | 73 | 38 | 17 | 20
3083415 | no | yes | 103 | 50 | 0.00213159 |  | 2031 | EDCOMTFF 500 -50 | 93 | 48 | 33 | 25
3083824 | yes | no | 83 | 40 | 0.00177705 | Main Model | 2321 | EDCOMTFF 500 -30 | 73 | 38 | 17 | 20
3083825 | no | yes | 103 | 50 | 0.00213159 | Main Model | 2322 | EDCOMTFF 500 -50 | 93 | 48 | 33 | 25

# IfcFlowTerminal: Compact Flange (6)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Compact; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Compact Flange; URL: https://www.easydrain.nl/douchegoten/compact-taf/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Wall profile: no; Flange: yes; WPS seal: no; Family Name: NLRS_PF_52_UN_Compact_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact Flange
Constraints - Offset: 0 mm; Level: Level: Level 1; Zero: no; Classic: yes; Grate Length: 500 mm; Host: Level : Level 1
Dimensions - NLRS_C_breedte: 60 mm; NLRS_C_lengte: 500 mm
Identity Data - NLRS_C_omschrijving: Compact Flens
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Closed cover: no; Family: NLRS_PF_52_UN_Compact_Easydrain: Compact Flange; Family and Type: NLRS_PF_52_UN_Compact_Easydrain: Compact Flange; Flange width: 100 mm; Length Calculated: 500 mm; max_length: 1200 mm; min_length: 500 mm; s: 1 mm; Type: NLRS_PF_52_UN_Compact_Easydrain: Compact Flange; Type Id: NLRS_PF_52_UN_Compact_Easydrain: Compact Flange
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Compact_Easydrain:Compact Flange:...) | Waterseal 30mm | Waterseal 50mm = Adjustable Legs | NLRS_C_hoogte (mm) = Build-in-Depth (mm) | NLRS_P_c01_diameter (mm) | Volume (m3) | Design Option | Mark | NLRS_C_code_product | connector_position (mm) | product_index | ro (mm)
3083353 | yes | no | 61 | 40 | 0.00120901 | Main Model | 2016 | EDCOMPR 500 -30 | 38 | 113 | 20
3083355 | no | yes | 81 | 50 | 0.00167166 |  | 2018 | EDCOMPR 500 -50 | 48 | 121 | 25
3961702 | yes | no | 61 | 40 | 0.00120901 | Main Model | 2680 | EDCOMPR 500 -30 | 38 | 113 | 20
3961703 | no | yes | 81 | 50 | 0.00167166 | Main Model | 2681 | EDCOMPR 500 -50 | 48 | 121 | 25
3961737 | yes | no | 61 | 40 | 0.00120901 | Main Model | 2692 | EDCOMPR 500 -30 | 38 | 113 | 20
3961738 | no | yes | 81 | 50 | 0.00167166 | Main Model | 2693 | EDCOMPR 500 -50 | 48 | 121 | 25

# IfcFlowTerminal: Compact M2, NLRS_PF_52_UN_Showerboard Compact M2_Easydrain:Compact M2:3374100
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Showerboard Compact M2; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Compact M2; URL: https://www.easydrain.nl/design-drains/s-line/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; m2_vertical: no; m2_flat: no; Siphon connection: no; Standard Siphon: yes; Family Name: NLRS_PF_52_UN_Showerboard Compact M2_Easydrain; Max_width: 1100 mm
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact M2
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Host: Level : Level 1; Showerboard Length: 1200 mm; Showerboard Width: 1100 mm; Tile Thickness: 7 mm
Dimensions - Do: 50 mm; Do1: 50 mm; Draingoot Length: 660 mm; NLRS_C_breedte: 127.3 mm; NLRS_C_hoogte: 114 mm; NLRS_C_lengte: 695 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.0464036 m3
Identity Data - Mark: 2573; NLRS_C_code_product: SBMOB-LINE-1; NLRS_C_omschrijving: Shower Board Compact M2
Mechanical - System Classification: Sanitary
Other - horizontal: yes; ref_line_angle: 180 deg; Siphon_angle: 90 deg; Distance to Draingoot: 120 mm; Distance to Wall: 158.3 mm; Draingoot_middle_Width: 127.3 mm; Draingoot Depth: 24.5 mm; Draingoot Height: 39 mm; DraingootLength_calculated: 695 mm; Family: NLRS_PF_52_UN_Showerboard Compact M2_Easydrain: Compact M2; Family and Type: NLRS_PF_52_UN_Showerboard Compact M2_Easydrain: Compact M2; Flange Width: 134 mm; L_/_: 17.5 mm; Length check: 1200 mm; Max_length: 1200 mm; Min_length: 900 mm; Min_width: 850 mm; Outlet_depth: 85 mm; Outlet_pos_length: 25 mm; Outlet_pos_width: 25 mm; Outlet Length: 168 mm; Ro: 25 mm; Ro1: 25 mm; s: 2.5 mm; Showerboard_thickness_end: 35 mm; Showerboard_thickness_wall: 33 mm; Siphon Depth: 79 mm; Siphon Length: 168 mm; Siphon Width: 120 mm; Tile_Thickness_check: 7 mm; Type: NLRS_PF_52_UN_Showerboard Compact M2_Easydrain: Compact M2; Type Id: NLRS_PF_52_UN_Showerboard Compact M2_Easydrain: Compact M2; Width check: 1100 mm
Phasing - Phase Created: New Construction

# IfcFlowTerminal: Compact M2 met M2 ondiep sifonhuis, NLRS_PF_52_UN_Showerboard Compact M2_Easydrain:Compact M2 met M2 ondiep sifonhuis:3374188
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Showerboard Compact M2; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Compact M2 met M2 ondiep sifonhuis; URL: https://www.easydrain.nl/design-drains/s-line/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; m2_vertical: no; m2_flat: yes; Siphon connection: yes; Standard Siphon: no; Family Name: NLRS_PF_52_UN_Showerboard Compact M2_Easydrain; Max_width: 1100 mm
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact M2 met M2 ondiep sifonhuis
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Host: Level : Level 1; Showerboard Length: 1200 mm; Showerboard Width: 1100 mm; Tile Thickness: 7 mm
Dimensions - Do: 40 mm; Do1: 50 mm; Draingoot Length: 660 mm; NLRS_C_breedte: 127.3 mm; NLRS_C_hoogte: 85 mm; NLRS_C_lengte: 695 mm; NLRS_P_c01_diameter: 40 mm; Volume: 0.0464036 m3
Identity Data - Mark: 2574; NLRS_C_code_product: SBMOB-LINE-1; NLRS_C_omschrijving: Shower Board Compact M2
Mechanical - System Classification: Sanitary
Other - horizontal: yes; ref_line_angle: 180 deg; Siphon_angle: 90 deg; Distance to Draingoot: 120 mm; Distance to Wall: 158.3 mm; Draingoot_middle_Width: 127.3 mm; Draingoot Depth: 24.5 mm; Draingoot Height: 39 mm; DraingootLength_calculated: 695 mm; Family: NLRS_PF_52_UN_Showerboard Compact M2_Easydrain: Compact M2 met M2 ondiep sifonhuis; Family and Type: NLRS_PF_52_UN_Showerboard Compact M2_Easydrain: Compact M2 met M2 ondiep sifonhuis; Flange Width: 134 mm; L_/_: 17.5 mm; Length check: 1200 mm; Max_length: 1200 mm; Min_length: 900 mm; Min_width: 850 mm; Outlet_depth: 53 mm; Outlet_pos_length: 25 mm; Outlet_pos_width: 25 mm; Outlet Length: 185 mm; Ro: 20 mm; Ro1: 25 mm; s: 2.5 mm; Showerboard_thickness_end: 35 mm; Showerboard_thickness_wall: 33 mm; Siphon Depth: 50 mm; Siphon Length: 185 mm; Siphon Width: 120 mm; Tile_Thickness_check: 7 mm; Type: NLRS_PF_52_UN_Showerboard Compact M2_Easydrain: Compact M2 met M2 ondiep sifonhuis; Type Id: NLRS_PF_52_UN_Showerboard Compact M2_Easydrain: Compact M2 met M2 ondiep sifonhuis; Width check: 1100 mm
Phasing - Phase Created: New Construction

# IfcFlowTerminal: Compact M2 met M2 sifonhuis onderuitloop, NLRS_PF_52_UN_Showerboard Compact M2_Easydrain:Compact M2 met M2 sifonhuis onderuitloop:3374267
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot verticale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Showerboard Compact M2; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Compact M2 met M2 sifonhuis onderuitloop; URL: https://www.easydrain.nl/design-drains/s-line/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; m2_vertical: yes; m2_flat: no; Siphon connection: yes; Standard Siphon: no; Family Name: NLRS_PF_52_UN_Showerboard Compact M2_Easydrain; Max_width: 1100 mm
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact M2 met M2 sifonhuis onderuitloop
Constraints - Level: Level: Level 1; Offset: 0 mm; Host: Level : Level 1; Showerboard Length: 1200 mm; Showerboard Width: 1100 mm; Siphon Orientation: 45 deg; Tile Thickness: 7 mm
Dimensions - Do: 50 mm; Do1: 50 mm; Draingoot Length: 660 mm; NLRS_C_breedte: 127.3 mm; NLRS_C_hoogte: 248 mm; NLRS_C_lengte: 695 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.0464036 m3
Identity Data - Design Option: Main Model; Mark: 2576; NLRS_C_code_product: SBMOB-LINE-1; NLRS_C_omschrijving: Shower Board Compact M2
Mechanical - System Classification: Sanitary
Other - horizontal: no; Siphon_angle: 180 deg; Distance to Draingoot: 120 mm; Distance to Wall: 158.3 mm; Draingoot_middle_Width: 127.3 mm; Draingoot Depth: 24.5 mm; Draingoot Height: 39 mm; DraingootLength_calculated: 695 mm; Family: NLRS_PF_52_UN_Showerboard Compact M2_Easydrain: Compact M2 met M2 sifonhuis onderuitloop; Family and Type: NLRS_PF_52_UN_Showerboard Compact M2_Easydrain: Compact M2 met M2 sifonhuis onderuitloop; Flange Width: 134 mm; L_/_: 17.5 mm; Length check: 1200 mm; Max_length: 1200 mm; Min_length: 900 mm; Min_width: 850 mm; Outlet_depth: 33 mm; Outlet_pos_length: 42.6777 mm; Outlet_pos_width: 42.6777 mm; Outlet Length: 213 mm; ref_line_angle: 225 deg; Ro: 25 mm; Ro1: 25 mm; s: 2.5 mm; Showerboard_thickness_end: 35 mm; Showerboard_thickness_wall: 33 mm; Siphon Depth: 213 mm; Siphon Length: 213 mm; Siphon Width: 120 mm; Tile_Thickness_check: 7 mm; Type: NLRS_PF_52_UN_Showerboard Compact M2_Easydrain: Compact M2 met M2 sifonhuis onderuitloop; Type Id: NLRS_PF_52_UN_Showerboard Compact M2_Easydrain: Compact M2 met M2 sifonhuis onderuitloop; Width check: 1100 mm
Phasing - Phase Created: New Construction

# IfcFlowTerminal: Compact Modulo Stone (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_e_natuursteen, NLRS_52_WPS_ EasyDrain
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Compact Modulo Stone; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Compact Modulo Stone; URL: https://www.easydrain.nl/douchegoten/modulo-stone/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_e_natuursteen
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Compact Modulo Stone_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact Modulo Stone
Constraints - Level: Level: Level 1; Offset: 0 mm; Grate Length: 800 mm; Host: Level : Level 1; Tile Thickness: 6 mm
Dimensions - NLRS_C_breedte: 62 mm; NLRS_C_lengte: 800 mm
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Tile: yes; Discharge Center: 400 mm; Family: NLRS_PF_52_UN_Compact Modulo Stone_Easydrain: Compact Modulo Stone; Family and Type: NLRS_PF_52_UN_Compact Modulo Stone_Easydrain: Compact Modulo Stone; Length calculated: 765 mm; max_length: 900 mm; s: 3 mm; Tile thickness calculated: 6 mm; Type: NLRS_PF_52_UN_Compact Modulo Stone_Easydrain: Compact Modulo Stone; Type Id: NLRS_PF_52_UN_Compact Modulo Stone_Easydrain: Compact Modulo Stone
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Compact Modulo Stone_Easydrain:Compact Modulo Stone:...) | Waterseal 30mm | Waterseal 50mm | NLRS_C_hoogte (mm) | NLRS_P_c01_diameter (mm) | Volume (m3) | Mark | NLRS_C_code_product | NLRS_C_omschrijving | Build-in-Depth (mm) | connector_position (mm) | ro (mm)
3376299 | yes | no | 69 | 40 | 0.00256809 | 2590 | EDM1NAT 800-30 | Compact 30 Modulo Stone | 63 | 38 | 20
3376407 | no | yes | 89 | 50 | 0.00290458 | 2591 | EDM1NAT 800-50 | Compact 50 Modulo Stone | 83 | 48 | 25

# IfcFlowTerminal: Compact TAF (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Compact TAF; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; Type Name: Compact TAF; URL: http://www.easydrain.nl/nl/easy-drain/compact/compact-taf.html
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; materiaal_WPS: NLRS_52_WPS_ EasyDrain; NLRS_C_materiaal_01: NLRS_n1_Asfalt_bitumen
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Compact TAF_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact TAF
