Properties of the parts of a building model (IFC2X3), part 7 of 9

# IfcFlowTerminal: S-Line met M2 sifonhuis onderuitloop, NLRS_PF_52_UN_Showerboard S-Line_Easydrain:S-Line met M2 sifonhuis onderuitloop:3373674
Other - horizontal: no; ref_line_angle: 180 deg; Draingoot_middle_Width: 108 mm; Draingoot Depth: 24.5 mm; Draingoot Height: 39 mm; DraingootLength_calculated: 695 mm; Draingoot Width: 33 mm; Family: NLRS_PF_52_UN_Showerboard S-Line_Easydrain: S-Line met M2 sifonhuis onderuitloop; Family and Type: NLRS_PF_52_UN_Showerboard S-Line_Easydrain: S-Line met M2 sifonhuis onderuitloop; Flange Width: 134 mm; L_/_: 17.5 mm; Length check: 1200 mm; Max_length: 1200 mm; Min_length: 900 mm; Min_width: 850 mm; Offset outlet: 220 mm; Outlet_depth: 43 mm; Outlet_pos_length: 25 mm; Outlet_pos_width: 50 mm; Outlet Length: 213 mm; Ro: 25 mm; Ro1: 25 mm; Showerboard_thickness_end: 46 mm; Showerboard_thickness_wall: 36 mm; Siphon_angle: 180 deg; Siphon Depth: 213 mm; Siphon Length: 213 mm; Siphon Width: 120 mm; Tile_Thickness_check: 7 mm; Tile_wall_Height: 8 mm; Tile_wall_Thickness: 9.6 mm; Tile Length: 192 mm; Type: NLRS_PF_52_UN_Showerboard S-Line_Easydrain: S-Line met M2 sifonhuis onderuitloop; Type Id: NLRS_PF_52_UN_Showerboard S-Line_Easydrain: S-Line met M2 sifonhuis onderuitloop; Width check: 1100 mm
Phasing - Phase Created: New Construction

# IfcFlowTerminal: Slim Siphon & Slim Waste - Installatie optie 1, NLRS_PF_52_UN_Slim Siphon Slim Waste_Easydrain:Slim Siphon & Slim Waste - Installatie optie 1:3059050
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat); Material: NLRS_n6_ABS_verlijmbaar
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Afvoerleiding; Manufacturer: Easy Sanitary Solutions; Model: Slim siphon & Slim waste; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.45.55.21; OmniClass Title: Drains (Wastes); Type Name: Slim Siphon & Slim Waste - Installatie optie 1; URL: https://www.easydrain.nl/afvoertechnieken/slim-siphon-slim-waste/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_n6_ABS_verlijmbaar
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Slim Siphon Slim Waste_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Slim Siphon & Slim Waste - Installatie optie 1
Constraints - Offset: 0 mm; Level: Level: Level 1; DischargePipe Depth: 105 mm; Host: Level : Level 1
Dimensions - Do: 40 mm; Do1: 32 mm; NLRS_C_hoogte: 105 mm; NLRS_P_c01_diameter: 32 mm; Volume: 0.000850291 m3
Identity Data - Design Option: Main Model; Mark: 1296; NLRS_C_code_product: SW - SET; NLRS_C_omschrijving: Slim Siphon & Slim Waste
Mechanical - System Classification: Sanitary
Other - DischargePipe_length_calculated: 105 mm; DischargePipe_radius: 15 mm; DischargePipe thickness: 30 mm; Family: NLRS_PF_52_UN_Slim Siphon Slim Waste_Easydrain: Slim Siphon & Slim Waste - Installatie optie 1; Family and Type: NLRS_PF_52_UN_Slim Siphon Slim Waste_Easydrain: Slim Siphon & Slim Waste - Installatie optie 1; Handle_length: 200 mm; Horizontal_end_length: 72 mm; Horizontal_length_calculated: 280 mm; max_length_horizontal: 230 mm; Siphon_connection_length: 52.5 mm; Siphon_height: 55 mm; Siphon Thickness: 47 mm; Tube depth: 15 mm; Tube Distance: 265 mm; Tube thickness: 70 mm; Tupe height: 110 mm; Type: NLRS_PF_52_UN_Slim Siphon Slim Waste_Easydrain: Slim Siphon & Slim Waste - Installatie optie 1; Type Id: NLRS_PF_52_UN_Slim Siphon Slim Waste_Easydrain: Slim Siphon & Slim Waste - Installatie optie 1; Vertical_end_length: 19 mm
Phasing - Phase Created: New Construction

# IfcFlowTerminal: Slim Siphon & Slim Waste - Installatie optie 2, NLRS_PF_52_UN_Slim Siphon Slim Waste_Easydrain:Slim Siphon & Slim Waste - Installatie optie 2:3059160
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat); Material: NLRS_n6_ABS_verlijmbaar
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Afvoerleiding; Manufacturer: Easy Sanitary Solutions; Model: Slim siphon & Slim waste; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.45.55.21; OmniClass Title: Drains (Wastes); Type Name: Slim Siphon & Slim Waste - Installatie optie 2; URL: https://www.easydrain.nl/afvoertechnieken/slim-siphon-slim-waste/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_n6_ABS_verlijmbaar
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Slim Siphon Slim Waste_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Slim Siphon & Slim Waste - Installatie optie 2
Constraints - Offset: 0 mm; Level: Level: Level 1; DischargePipe Depth: 105 mm; Host: Level : Level 1
Dimensions - Do: 40 mm; Do1: 32 mm; NLRS_C_hoogte: 105 mm; NLRS_P_c01_diameter: 32 mm; Volume: 0.000833862 m3
Identity Data - Mark: 1297; NLRS_C_code_product: SW - SET; NLRS_C_omschrijving: Slim Siphon & Slim Waste
Mechanical - System Classification: Sanitary
Other - DischargePipe_length_calculated: 105 mm; DischargePipe_radius: 15 mm; DischargePipe thickness: 30 mm; Family: NLRS_PF_52_UN_Slim Siphon Slim Waste_Easydrain: Slim Siphon & Slim Waste - Installatie optie 2; Family and Type: NLRS_PF_52_UN_Slim Siphon Slim Waste_Easydrain: Slim Siphon & Slim Waste - Installatie optie 2; Handle_length: 200 mm; Horizontal_end_length: 72 mm; Horizontal_length_calculated: 250 mm; max_length_horizontal: 235 mm; Siphon_connection_length: 52.5 mm; Siphon_height: 55 mm; Siphon Thickness: 47 mm; Tube depth: 45 mm; Tube Distance: 260 mm; Tube thickness: 70 mm; Tupe height: 110 mm; Type: NLRS_PF_52_UN_Slim Siphon Slim Waste_Easydrain: Slim Siphon & Slim Waste - Installatie optie 2; Type Id: NLRS_PF_52_UN_Slim Siphon Slim Waste_Easydrain: Slim Siphon & Slim Waste - Installatie optie 2; Vertical_end_length: 19 mm
Phasing - Phase Created: New Construction

# IfcFlowTerminal: Slim Siphon & Slim Waste - Installatie optie 3, NLRS_PF_52_UN_Slim Siphon Slim Waste_Easydrain:Slim Siphon & Slim Waste - Installatie optie 3:3059453
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat); Material: NLRS_n6_ABS_verlijmbaar
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Afvoerleiding; Manufacturer: Easy Sanitary Solutions; Model: Slim siphon & Slim waste; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.45.55.21; OmniClass Title: Drains (Wastes); Type Name: Slim Siphon & Slim Waste - Installatie optie 3; URL: https://www.easydrain.nl/afvoertechnieken/slim-siphon-slim-waste/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_n6_ABS_verlijmbaar
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Slim Siphon Slim Waste_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Slim Siphon & Slim Waste - Installatie optie 3
Constraints - Offset: 0 mm; Level: Level: Level 1; DischargePipe Depth: 105 mm; Host: Level : Level 1
Dimensions - Do: 40 mm; Do1: 32 mm; NLRS_C_hoogte: 105 mm; NLRS_P_c01_diameter: 32 mm; Volume: 0.000876272 m3
Identity Data - Mark: 1298; NLRS_C_code_product: SW - SET; NLRS_C_omschrijving: Slim Siphon & Slim Waste
Mechanical - System Classification: Sanitary
Other - DischargePipe_length_calculated: 105 mm; DischargePipe_radius: 15 mm; DischargePipe thickness: 30 mm; Family: NLRS_PF_52_UN_Slim Siphon Slim Waste_Easydrain: Slim Siphon & Slim Waste - Installatie optie 3; Family and Type: NLRS_PF_52_UN_Slim Siphon Slim Waste_Easydrain: Slim Siphon & Slim Waste - Installatie optie 3; Handle_length: 200 mm; Horizontal_end_length: 72 mm; Horizontal_length_calculated: 250 mm; max_length_horizontal: 235 mm; Siphon_connection_length: 52.5 mm; Siphon_height: 55 mm; Siphon Thickness: 47 mm; Tube depth: 105 mm; Tube Distance: 260 mm; Tube thickness: 70 mm; Tupe height: 110 mm; Type: NLRS_PF_52_UN_Slim Siphon Slim Waste_Easydrain: Slim Siphon & Slim Waste - Installatie optie 3; Type Id: NLRS_PF_52_UN_Slim Siphon Slim Waste_Easydrain: Slim Siphon & Slim Waste - Installatie optie 3; Vertical_end_length: 79 mm
Phasing - Phase Created: New Construction

# IfcFlowTerminal: Slim Siphon XF & Slim Waste, NLRS_PF_52_UN_Slim Siphon XF Slim Waste_Easydrain:Slim Siphon XF & Slim Waste:3058928
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat); Material: NLRS_n6_ABS_verlijmbaar
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Afvoerleiding; Manufacturer: Easy Sanitary Solutions; Model: Slim siphon XF & Slim waste; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.45.55.21; OmniClass Title: Drains (Wastes); Type Name: Slim Siphon XF & Slim Waste; URL: https://www.easydrain.nl/afvoertechnieken/slim-siphon-xf-slim-waste-afvoerbuis/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_n6_ABS_verlijmbaar
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Slim Siphon XF Slim Waste_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Slim Siphon XF & Slim Waste
Constraints - Offset: 0 mm; Level: Level: Level 1; DischargePipe Depth: 60 mm; Host: Level : Level 1
Dimensions - Do: 40 mm; Do1: 32 mm; NLRS_C_hoogte: 60 mm; NLRS_P_c01_diameter: 32 mm; Volume: 0.000442001 m3
Identity Data - Mark: 1295; NLRS_C_code_product: XF - SET; NLRS_C_omschrijving: Slim Siphon XF & Slim Waste
Mechanical - System Classification: Sanitary
Other - DischargePipe_length_calculated: 60 mm; DischargePipe_radius: 15 mm; DischargePipe_Thickness: 30 mm; Family: NLRS_PF_52_UN_Slim Siphon XF Slim Waste_Easydrain: Slim Siphon XF & Slim Waste; Family and Type: NLRS_PF_52_UN_Slim Siphon XF Slim Waste_Easydrain: Slim Siphon XF & Slim Waste; Handle_length: 200 mm; Horizontal_length_calculated: 250 mm; Horizontal_outlet_length: 57 mm; max_length_horizontal: 235 mm; Siphon_connection_length: 52.5 mm; Siphon_height: 55 mm; Siphon_thickness: 47 mm; Type: NLRS_PF_52_UN_Slim Siphon XF Slim Waste_Easydrain: Slim Siphon XF & Slim Waste; Type Id: NLRS_PF_52_UN_Slim Siphon XF Slim Waste_Easydrain: Slim Siphon XF & Slim Waste; Vertical_outlet_length: 105 mm
Phasing - Phase Created: New Construction

# IfcFlowTerminal: Slim Tube (3)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat); Material: NLRS_n6_PVC_verlijmbaar
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Slim Tube; Manufacturer: Easy Sanitary Solutions; Model: Slim Series; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.45.55.21; OmniClass Title: Drains (Wastes); Type Name: Slim Tube; URL: https://www.easydrain.nl/afvoertechnieken/slimtube/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_n6_PVC_verlijmbaar
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: Z_DO_NOT_USE_NLRS_PF_52_UN_Slim Tube drain pipe_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Slim Tube
Constraints - Moves With Nearby Elements: no; Level: Level: Level 1; Host: Level : Level 1; Offset: -33 mm; slim_tube_lengte: 750 mm
Dimensions - Area: 0.0617231 m2; NLRS_C_breedte: 65 mm; NLRS_C_lengte: 750 mm; Volume: 0.000983125 m3
Identity Data - NLRS_C_code_product: STE-01; NLRS_C_omschrijving: Slim Tube
Other - Family: Z_DO_NOT_USE_NLRS_PF_52_UN_Slim Tube drain pipe_Easydrain: Slim Tube; Family and Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Slim Tube drain pipe_Easydrain: Slim Tube; lengte_berekend: 750 mm; slim_tube_breedte: 65 mm; slim_tube_dikte: 22 mm; Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Slim Tube drain pipe_Easydrain: Slim Tube; Type Id: Z_DO_NOT_USE_NLRS_PF_52_UN_Slim Tube drain pipe_Easydrain: Slim Tube
Phasing - Phase Created: New Construction
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Slim Tube drain pipe_Easydrain:Slim Tube:...) | Mark
3059643 | 1301
3059717 | 1305
3059788 | 1309

# IfcFlowTerminal: Slim Tube - lengte 3,2 m (3)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat); Material: NLRS_n6_PVC_verlijmbaar
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Slim Tube L = 3,2 m; Manufacturer: Easy Sanitary Solutions; Model: Slim Series; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.45.55.21; OmniClass Title: Drains (Wastes); Type Name: Slim Tube - lengte 3,2 m; URL: https://www.easydrain.nl/afvoertechnieken/slimtube/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_n6_PVC_verlijmbaar
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: Z_DO_NOT_USE_NLRS_PF_52_UN_Slim Tube drain pipe lengte 3,2m_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Slim Tube - lengte 3,2 m
Constraints - Moves With Nearby Elements: no; Level: Level: Level 1; Host: Level : Level 1; Offset: -33 mm; slim_tube_lengte: 3200 mm
Dimensions - Area: 0.25907 m2; NLRS_C_breedte: 65 mm; NLRS_C_lengte: 3200 mm; Volume: 0.00419467 m3
Identity Data - NLRS_C_code_product: STL-32; NLRS_C_omschrijving: Slim Tube Lengte = 3,2m
Other - Family: Z_DO_NOT_USE_NLRS_PF_52_UN_Slim Tube drain pipe lengte 3,2m_Easydrain: Slim Tube - lengte 3,2 m; Family and Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Slim Tube drain pipe lengte 3,2m_Easydrain: Slim Tube - lengte 3,2 m; lengte_berekend: 3200 mm; slim_tube_breedte: 65 mm; slim_tube_dikte: 22 mm; Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Slim Tube drain pipe lengte 3,2m_Easydrain: Slim Tube - lengte 3,2 m; Type Id: Z_DO_NOT_USE_NLRS_PF_52_UN_Slim Tube drain pipe lengte 3,2m_Easydrain: Slim Tube - lengte 3,2 m
Phasing - Phase Created: New Construction
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Slim Tube drain pipe lengte 3,2m_Easydrain:Slim Tube - lengte 3,2 m:...) | Mark
3059869 | 1314
3059951 | 1318
3060013 | 1322

# IfcFlowTerminal: Slim Tube outgoing facing down (2)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat); Material: NLRS_n6_PVC_verlijmbaar
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Slim Tube sifon uitlaat onder; Manufacturer: Easy Sanitary Solutions; Model: Slim Series; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.45.55.21; OmniClass Title: Drains (Wastes); Type Name: Slim Tube outgoing facing down; URL: https://www.easydrain.nl/afvoertechnieken/slimtube/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_n6_PVC_verlijmbaar
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: Z_DO_NOT_USE_NLRS_PF_52_UN_Slim Tube outgoing facing down_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Slim Tube outgoing facing down
Constraints - Moves With Nearby Elements: no; Offset: 0 mm; Level: Level: Level 1; Host: Level : Level 1
Dimensions - Area: 0.00650143 m2; Do: 40 mm; NLRS_C_hoogte: 55 mm; NLRS_P_c01_diameter: 40 mm; Volume: 0.0000705767 m3
Identity Data - Design Option: Main Model; NLRS_C_code_product: STB-04; NLRS_C_omschrijving: Slim Tube met onderuitloop
Other - aansluiting_breedte: 22 mm; aansluiting_hoogte: 27 mm; Family: Z_DO_NOT_USE_NLRS_PF_52_UN_Slim Tube outgoing facing down_Easydrain: Slim Tube outgoing facing down; Family and Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Slim Tube outgoing facing down_Easydrain: Slim Tube outgoing facing down; Ro: 20 mm; siphon_breedte: 65 mm; siphon_hoogte: 55 mm; Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Slim Tube outgoing facing down_Easydrain: Slim Tube outgoing facing down; Type Id: Z_DO_NOT_USE_NLRS_PF_52_UN_Slim Tube outgoing facing down_Easydrain: Slim Tube outgoing facing down
Phasing - Phase Created: New Construction
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Slim Tube outgoing facing down_Easydrain:Slim Tube outgoing facing down:...) | Mark | uitgang_diepte (mm)
3059644 | 1302 | 783
3059868 | 1313 | 3233

# IfcFlowTerminal: Slim Tube outgoing front (2)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat); Material: NLRS_n6_PVC_verlijmbaar
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Slim Tube sifon uitlaat voor; Manufacturer: Easy Sanitary Solutions; Model: Slim Series; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.45.55.21; OmniClass Title: Drains (Wastes); Type Name: Slim Tube outgoing front; URL: https://www.easydrain.nl/afvoertechnieken/slimtube/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_n6_PVC_verlijmbaar
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: Z_DO_NOT_USE_NLRS_PF_52_UN_Slim Tube outgoing front_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Slim Tube outgoing front
Constraints - Moves With Nearby Elements: no; Offset: 0 mm; Level: Level: Level 1; Host: Level : Level 1
Dimensions - Area: 0.012346 m2; Do: 50 mm; NLRS_C_hoogte: 55 mm; NLRS_C_lengte: 50 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.000137326 m3
Identity Data - NLRS_C_code_product: STB-02; NLRS_C_omschrijving: Slim Tube bocht 90°
Other - aansluiting_breedte: 22 mm; bol_hoogte: 11 mm; Family: Z_DO_NOT_USE_NLRS_PF_52_UN_Slim Tube outgoing front_Easydrain: Slim Tube outgoing front; Family and Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Slim Tube outgoing front_Easydrain: Slim Tube outgoing front; Ro: 25 mm; siphon_breedte: 65 mm; siphon_hoogte: 55 mm; siphon_lengte: 50 mm; Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Slim Tube outgoing front_Easydrain: Slim Tube outgoing front; Type Id: Z_DO_NOT_USE_NLRS_PF_52_UN_Slim Tube outgoing front_Easydrain: Slim Tube outgoing front; uitlaat_diepte: 30 mm
Phasing - Phase Created: New Construction
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Slim Tube outgoing front_Easydrain:Slim Tube outgoing front:...) | Mark | uitgang_diepte (mm)
3059718 | 1306 | 783
3059950 | 1317 | 3233 | Identity Data - Design Option: Main Model

# IfcFlowTerminal: Slim Tube outgoing rear (2)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat); Material: NLRS_n6_PVC_verlijmbaar
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Slim Tube sifon uitlaat achter; Manufacturer: Easy Sanitary Solutions; Model: Slim Series; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.45.55.21; OmniClass Title: Drains (Wastes); Type Name: Slim Tube outgoing rear; URL: https://www.easydrain.nl/afvoertechnieken/slimtube/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_n6_PVC_verlijmbaar
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: Z_DO_NOT_USE_NLRS_PF_52_UN_Slim Tube outgoing rear_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Slim Tube outgoing rear
Constraints - Moves With Nearby Elements: no; Offset: 0 mm; Level: Level: Level 1; Host: Level : Level 1
Dimensions - Area: 0.0132099 m2; Do: 50 mm; NLRS_C_hoogte: 55 mm; NLRS_C_lengte: 50 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.000158923 m3
Identity Data - Design Option: Main Model; NLRS_C_code_product: STB-01; NLRS_C_omschrijving: Slim Tube Bocht 90°
Other - aansluiting_breedte: 22 mm; bol_hoogte: 11 mm; Family: Z_DO_NOT_USE_NLRS_PF_52_UN_Slim Tube outgoing rear_Easydrain: Slim Tube outgoing rear; Family and Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Slim Tube outgoing rear_Easydrain: Slim Tube outgoing rear; Ro: 25 mm; siphon_breedte: 65 mm; siphon_hoogte: 55 mm; siphon_lengte: 50 mm; Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Slim Tube outgoing rear_Easydrain: Slim Tube outgoing rear; Type Id: Z_DO_NOT_USE_NLRS_PF_52_UN_Slim Tube outgoing rear_Easydrain: Slim Tube outgoing rear; uitlaat_diepte: 30 mm
Phasing - Phase Created: New Construction
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Slim Tube outgoing rear_Easydrain:Slim Tube outgoing rear:...) | Mark | uitgang_diepte (mm)
3059789 | 1310 | 783
3060012 | 1321 | 3233

# IfcFlowTerminal: Slim Tube siphon connection (6)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat)
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Slim Tube sifon aansluiting; Manufacturer: Easy Sanitary Solutions; Model: Slim Series; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.45.55.21; OmniClass Title: Drains (Wastes); Type Name: Slim Tube siphon connection; URL: https://www.easydrain.nl/afvoertechnieken/slimtube/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_n6_PVC_verlijmbaar
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: Z_DO_NOT_USE_NLRS_PF_52_UN_Slim Tube siphon connection_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Slim Tube siphon connection
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm; Host: Level : Level 1
Dimensions - Area: 0.010193 m2; Do: 40 mm; NLRS_C_diameter: 40 mm; NLRS_C_hoogte: 56 mm; NLRS_C_lengte: 50 mm; Volume: 0.000114319 m3
Identity Data - NLRS_C_code_product: STB-03; NLRS_C_omschrijving: Slim Tube bovenbocht 90°
Other - aansluiting_breedte: 22 mm; Family: Z_DO_NOT_USE_NLRS_PF_52_UN_Slim Tube siphon connection_Easydrain: Slim Tube siphon connection; Family and Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Slim Tube siphon connection_Easydrain: Slim Tube siphon connection; siphon_breedte: 65 mm; siphon_hoogte: 56 mm; siphon_lengte: 50 mm; Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Slim Tube siphon connection_Easydrain: Slim Tube siphon connection; Type Id: Z_DO_NOT_USE_NLRS_PF_52_UN_Slim Tube siphon connection_Easydrain: Slim Tube siphon connection
Phasing - Phase Created: New Construction
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Slim Tube siphon connection_Easydrain:Slim Tube siphon connection:...) | Design Option | Mark
3059642 | Main Model | 1300
3059716 |  | 1304
3059787 | Main Model | 1308
3059867 |  | 1312
3059949 | Main Model | 1316
3060011 | Main Model | 1320

# IfcFlowTerminal: Square Onderuitloop 50 mm, NLRS_PF_52_UN_Showerboard SQUARE_uitloop_Easydrain:Square Onderuitloop 50 mm:3373048
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, Default
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot verticale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Square; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Square Onderuitloop 50 mm; URL: http://www.easydrain.nl/doucheputten/square/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Showerboard SQUARE_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Square Onderuitloop 50 mm
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Bottom Plate: yes; Build-in-Depth: 80 mm; Host: Level : Level 1; Tile Thickness: 9 mm
Dimensions - Do: 102 mm; Do1: 50 mm; NLRS_C_hoogte: 90 mm; NLRS_C_lengte: 1200 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.118872 m3
Identity Data - Mark: 2556; NLRS_C_code_product: EDDOT-SQ; NLRS_C_omschrijving: Shower Board SQUARE
Mechanical - System Classification: Sanitary
Other - E: 0 mm; siphon_angle: 180 deg; Board height: 40 mm; discharge_void_length: 50 mm; Family: NLRS_PF_52_UN_Showerboard SQUARE_uitloop_Easydrain: Square Onderuitloop 50 mm; Family and Type: NLRS_PF_52_UN_Showerboard SQUARE_uitloop_Easydrain: Square Onderuitloop 50 mm; H_Siphon: 90 mm; offset outlet: 99 mm; offset siphon: -9 mm; Outlet Depth: 90 mm; Outlet Length: 550 mm; Outlet Width: 550 mm; Showerboard baseheight: 31 mm; Showerboard Height: 50 mm; Showerboard Length: 1200 mm; Showerboard Width: 1100 mm; Siphon_outlet_length: 40 mm; Siphon Depth: 121 mm; Siphon Height: 90 mm; Siphon offset: -31 mm; Tile_thickness_check: 9 mm; Tile Diameter: 658 mm; Type: NLRS_PF_52_UN_Showerboard SQUARE_uitloop_Easydrain: Square Onderuitloop 50 mm; Type Id: NLRS_PF_52_UN_Showerboard SQUARE_uitloop_Easydrain: Square Onderuitloop 50 mm; Void Diameter: 676 mm; Waterseal: 35 mm
Phasing - Phase Created: New Construction

# IfcFlowTerminal: Square Zijuitloop hoog 50 mm, NLRS_PF_52_UN_Showerboard SQUARE_uitloop_Easydrain:Square Zijuitloop hoog 50 mm:3372959
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, Default
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Square; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Square Zijuitloop hoog 50 mm; URL: http://www.easydrain.nl/doucheputten/square/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Showerboard SQUARE_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Square Zijuitloop hoog 50 mm
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Bottom Plate: yes; Build-in-Depth: 80 mm; Host: Level : Level 1; Tile Thickness: 9 mm
Dimensions - Do: 102 mm; Do1: 50 mm; NLRS_C_hoogte: 90 mm; NLRS_C_lengte: 1200 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.117622 m3
Identity Data - Design Option: Main Model; Mark: 2554; NLRS_C_code_product: EDDOT-SQ; NLRS_C_omschrijving: Shower Board SQUARE
Mechanical - System Classification: Sanitary
Other - siphon_angle: 90 deg; Board height: 40 mm; discharge_void_length: 1500 mm; E: 54 mm; Family: NLRS_PF_52_UN_Showerboard SQUARE_uitloop_Easydrain: Square Zijuitloop hoog 50 mm; Family and Type: NLRS_PF_52_UN_Showerboard SQUARE_uitloop_Easydrain: Square Zijuitloop hoog 50 mm; H_Siphon: 90 mm; offset outlet: 45 mm; offset siphon: -9 mm; Outlet Depth: 36 mm; Outlet Length: 550 mm; Outlet Width: 550 mm; Showerboard baseheight: 31 mm; Showerboard Height: 50 mm; Showerboard Length: 1200 mm; Showerboard Width: 1100 mm; Siphon_outlet_length: 91 mm; Siphon Depth: 121 mm; Siphon Height: 90 mm; Siphon offset: -31 mm; Tile_thickness_check: 9 mm; Tile Diameter: 658 mm; Type: NLRS_PF_52_UN_Showerboard SQUARE_uitloop_Easydrain: Square Zijuitloop hoog 50 mm; Type Id: NLRS_PF_52_UN_Showerboard SQUARE_uitloop_Easydrain: Square Zijuitloop hoog 50 mm; Void Diameter: 676 mm; Waterseal: 50 mm
Phasing - Phase Created: New Construction

# IfcFlowTerminal: Square Zijuitloop laag 40 mm, NLRS_PF_52_UN_Showerboard SQUARE_uitloop_Easydrain:Square Zijuitloop laag 40 mm:3372786
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, Default
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Square; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Square Zijuitloop laag 40 mm; URL: http://www.easydrain.nl/doucheputten/square/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Showerboard SQUARE_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Square Zijuitloop laag 40 mm
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Bottom Plate: yes; Build-in-Depth: 80 mm; Host: Level : Level 1; Tile Thickness: 9 mm
Dimensions - Do: 102 mm; Do1: 40 mm; NLRS_C_hoogte: 90 mm; NLRS_C_lengte: 1200 mm; NLRS_P_c01_diameter: 40 mm; Volume: 0.117897 m3
Identity Data - Design Option: Main Model; Mark: 2550; NLRS_C_code_product: EDDOT-SQ; NLRS_C_omschrijving: Shower Board SQUARE
Mechanical - System Classification: Sanitary
Other - siphon_angle: 90 deg; Board height: 40 mm; discharge_void_length: 1500 mm; E: 20 mm; Family: NLRS_PF_52_UN_Showerboard SQUARE_uitloop_Easydrain: Square Zijuitloop laag 40 mm; Family and Type: NLRS_PF_52_UN_Showerboard SQUARE_uitloop_Easydrain: Square Zijuitloop laag 40 mm; H_Siphon: 54 mm; offset outlet: 69 mm; offset siphon: -9 mm; Outlet Depth: 60 mm; Outlet Length: 550 mm; Outlet Width: 550 mm; Showerboard baseheight: 31 mm; Showerboard Height: 50 mm; Showerboard Length: 1200 mm; Showerboard Width: 1100 mm; Siphon_outlet_length: 91 mm; Siphon Depth: 111 mm; Siphon Height: 80 mm; Siphon offset: -31 mm; Tile_thickness_check: 9 mm; Tile Diameter: 658 mm; Type: NLRS_PF_52_UN_Showerboard SQUARE_uitloop_Easydrain: Square Zijuitloop laag 40 mm; Type Id: NLRS_PF_52_UN_Showerboard SQUARE_uitloop_Easydrain: Square Zijuitloop laag 40 mm; Void Diameter: 676 mm; Waterseal: 30 mm
Phasing - Phase Created: New Construction

# IfcFlowTerminal: Square Zijuitloop laag 50 mm, NLRS_PF_52_UN_Showerboard SQUARE_uitloop_Easydrain:Square Zijuitloop laag 50 mm:3372866
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, Default
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Square; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Square Zijuitloop laag 50 mm; URL: http://www.easydrain.nl/doucheputten/square/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Showerboard SQUARE_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Square Zijuitloop laag 50 mm
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Bottom Plate: yes; Build-in-Depth: 80 mm; Host: Level : Level 1; Tile Thickness: 9 mm
Dimensions - Do: 102 mm; Do1: 50 mm; NLRS_C_hoogte: 90 mm; NLRS_C_lengte: 1200 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.117622 m3
Identity Data - Design Option: Main Model; Mark: 2552; NLRS_C_code_product: EDDOT-SQ; NLRS_C_omschrijving: Shower Board SQUARE
Mechanical - System Classification: Sanitary
Other - siphon_angle: 90 deg; Board height: 40 mm; discharge_void_length: 1500 mm; E: 23 mm; Family: NLRS_PF_52_UN_Showerboard SQUARE_uitloop_Easydrain: Square Zijuitloop laag 50 mm; Family and Type: NLRS_PF_52_UN_Showerboard SQUARE_uitloop_Easydrain: Square Zijuitloop laag 50 mm; H_Siphon: 59 mm; offset outlet: 66 mm; offset siphon: -9 mm; Outlet Depth: 57 mm; Outlet Length: 550 mm; Outlet Width: 550 mm; Showerboard baseheight: 31 mm; Showerboard Height: 50 mm; Showerboard Length: 1200 mm; Showerboard Width: 1100 mm; Siphon_outlet_length: 91 mm; Siphon Depth: 111 mm; Siphon Height: 80 mm; Siphon offset: -31 mm; Tile_thickness_check: 9 mm; Tile Diameter: 658 mm; Type: NLRS_PF_52_UN_Showerboard SQUARE_uitloop_Easydrain: Square Zijuitloop laag 50 mm; Type Id: NLRS_PF_52_UN_Showerboard SQUARE_uitloop_Easydrain: Square Zijuitloop laag 50 mm; Void Diameter: 676 mm; Waterseal: 35 mm
Phasing - Phase Created: New Construction

# IfcFlowTerminal: Square onderuitloop 50mm, zij-ingang 40mm, NLRS_PF_52_UN_Showerboard SQUARE_in_uitloop_Easydrain:Square onderuitloop 50mm, zij-ingang 40mm:3373208
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, Default
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot verticale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Square; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Square onderuitloop 50mm, zij-ingang 40mm; URL: http://www.easydrain.nl/doucheputten/square/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Showerboard SQUARE_in_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Square onderuitloop 50mm, zij-ingang 40mm
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Bottom Plate: yes; Build-in-Depth: 90 mm; Host: Level : Level 1; Tile Thickness: 9 mm
Dimensions - Do: 102 mm; Do1: 50 mm; Do2: 40 mm; NLRS_C_hoogte: 90 mm; NLRS_C_lengte: 1200 mm; NLRS_P_c01_diameter: 50 mm; NLRS_P_c02_diameter: 40 mm; Volume: 0.112859 m3
Identity Data - Design Option: Main Model; Mark: 2560; NLRS_C_code_product: EDDOT-SQ; NLRS_C_omschrijving: Shower Board Square
Mechanical - System Classification: Sanitary
Other - E1: 0 mm; siphon_angle: 180 deg; Board height: 40 mm; discharge_void_length: 1500 mm; E2: 49 mm; Family: NLRS_PF_52_UN_Showerboard SQUARE_in_uitloop_Easydrain: Square onderuitloop 50mm, zij-ingang 40mm; Family and Type: NLRS_PF_52_UN_Showerboard SQUARE_in_uitloop_Easydrain: Square onderuitloop 50mm, zij-ingang 40mm; H_Siphon: 90 mm; Inlet Depth: 41 mm; offset_siphon: -9 mm; Outlet Depth: 90 mm; Outlet Length: 550 mm; Outlet Width: 550 mm; Showerboard baseheight: 31 mm; Showerboard Height: 50 mm; Showerboard Length: 1200 mm; Showerboard Width: 1100 mm; Siphon_inlet_length: 91 mm; Siphon_outlet_length: 40 mm; Siphon height calculated: 90 mm; Tile_thickness_check: 9 mm; Tile Diameter: 658 mm; Type: NLRS_PF_52_UN_Showerboard SQUARE_in_uitloop_Easydrain: Square onderuitloop 50mm, zij-ingang 40mm; Type Id: NLRS_PF_52_UN_Showerboard SQUARE_in_uitloop_Easydrain: Square onderuitloop 50mm, zij-ingang 40mm; Void Diameter: 676 mm
Phasing - Phase Created: New Construction

# IfcFlowTerminal: Square onderuitloop 50mm, zij-ingang 50mm, NLRS_PF_52_UN_Showerboard SQUARE_in_uitloop_Easydrain:Square onderuitloop 50mm, zij-ingang 50mm:3373300
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, Default
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot verticale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Square; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Square onderuitloop 50mm, zij-ingang 50mm; URL: http://www.easydrain.nl/doucheputten/square/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Showerboard SQUARE_in_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Square onderuitloop 50mm, zij-ingang 50mm
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Bottom Plate: yes; Build-in-Depth: 90 mm; Host: Level : Level 1; Tile Thickness: 9 mm
Dimensions - Do: 102 mm; Do1: 50 mm; Do2: 50 mm; NLRS_C_hoogte: 90 mm; NLRS_C_lengte: 1200 mm; NLRS_P_c01_diameter: 50 mm; NLRS_P_c02_diameter: 50 mm; Volume: 0.112859 m3
Identity Data - Design Option: Main Model; Mark: 2562; NLRS_C_code_product: EDDOT-SQ; NLRS_C_omschrijving: Shower Board Square
Mechanical - System Classification: Sanitary
Other - E1: 0 mm; siphon_angle: 180 deg; Board height: 40 mm; discharge_void_length: 1500 mm; E2: 54 mm; Family: NLRS_PF_52_UN_Showerboard SQUARE_in_uitloop_Easydrain: Square onderuitloop 50mm, zij-ingang 50mm; Family and Type: NLRS_PF_52_UN_Showerboard SQUARE_in_uitloop_Easydrain: Square onderuitloop 50mm, zij-ingang 50mm; H_Siphon: 90 mm; Inlet Depth: 36 mm; offset_siphon: -9 mm; Outlet Depth: 90 mm; Outlet Length: 550 mm; Outlet Width: 550 mm; Showerboard baseheight: 31 mm; Showerboard Height: 50 mm; Showerboard Length: 1200 mm; Showerboard Width: 1100 mm; Siphon_inlet_length: 91 mm; Siphon_outlet_length: 40 mm; Siphon height calculated: 90 mm; Tile_thickness_check: 9 mm; Tile Diameter: 658 mm; Type: NLRS_PF_52_UN_Showerboard SQUARE_in_uitloop_Easydrain: Square onderuitloop 50mm, zij-ingang 50mm; Type Id: NLRS_PF_52_UN_Showerboard SQUARE_in_uitloop_Easydrain: Square onderuitloop 50mm, zij-ingang 50mm; Void Diameter: 676 mm
Phasing - Phase Created: New Construction

# IfcFlowTerminal: Square zijuitloop hoog 50mm, zij-ingang 40mm, NLRS_PF_52_UN_Showerboard SQUARE_in_uitloop_Easydrain:Square zijuitloop hoog 50mm, zij-ingang 40mm:3373130
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, Default
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Square; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Square zijuitloop hoog 50mm, zij-ingang 40mm; URL: http://www.easydrain.nl/doucheputten/square/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Showerboard SQUARE_in_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Square zijuitloop hoog 50mm, zij-ingang 40mm
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Bottom Plate: yes; Build-in-Depth: 90 mm; Host: Level : Level 1; Tile Thickness: 9 mm
Dimensions - Do: 102 mm; Do1: 50 mm; Do2: 40 mm; NLRS_C_hoogte: 90 mm; NLRS_C_lengte: 1200 mm; NLRS_P_c01_diameter: 50 mm; NLRS_P_c02_diameter: 40 mm; Volume: 0.112859 m3
Identity Data - Mark: 2558; NLRS_C_code_product: EDDOT-SQ; NLRS_C_omschrijving: Shower Board Square
Mechanical - System Classification: Sanitary
Other - siphon_angle: 90 deg; Board height: 40 mm; discharge_void_length: 1500 mm; E1: 54 mm; E2: 49 mm; Family: NLRS_PF_52_UN_Showerboard SQUARE_in_uitloop_Easydrain: Square zijuitloop hoog 50mm, zij-ingang 40mm; Family and Type: NLRS_PF_52_UN_Showerboard SQUARE_in_uitloop_Easydrain: Square zijuitloop hoog 50mm, zij-ingang 40mm; H_Siphon: 90 mm; Inlet Depth: 41 mm; offset_siphon: -9 mm; Outlet Depth: 36 mm; Outlet Length: 550 mm; Outlet Width: 550 mm; Showerboard baseheight: 31 mm; Showerboard Height: 50 mm; Showerboard Length: 1200 mm; Showerboard Width: 1100 mm; Siphon_inlet_length: 91 mm; Siphon_outlet_length: 91 mm; Siphon height calculated: 90 mm; Tile_thickness_check: 9 mm; Tile Diameter: 658 mm; Type: NLRS_PF_52_UN_Showerboard SQUARE_in_uitloop_Easydrain: Square zijuitloop hoog 50mm, zij-ingang 40mm; Type Id: NLRS_PF_52_UN_Showerboard SQUARE_in_uitloop_Easydrain: Square zijuitloop hoog 50mm, zij-ingang 40mm; Void Diameter: 676 mm
Phasing - Phase Created: New Construction

# IfcFlowTerminal: Tile 10x10 (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_52_WPS_ EasyDrain, Default, NLRS_h2_RVS_geborsteld
Type - Dimensions - Grate Length: 100 mm; Grate Width: 100 mm
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Aqua Jewels Quatro voor Natuursteen; Manufacturer: Easy Sanitary Solutions; Model: Aqua Jewels Quatro; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Tile 10x10; URL: http://www.easydrain.com/linear-shower-drains/series/modulo-design/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: Default
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Tile Complete_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Tile 10x10
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm; WPS: yes; Host: Level : Level 1; Tile Thickness: 17 mm
Dimensions - Flange length: 160 mm; Flange width: 160 mm; Grate Depth: 20 mm; NLRS_C_breedte: 100 mm; NLRS_C_lengte: 100 mm; Volume: 0.0006101 m3
Identity Data - NLRS_C_code_product: AJQ-10X10-T-HOOG; NLRS_C_omschrijving: Aqua Jewels Quatro - Tile for Natural Stone
Other - offset_length: 0 mm; offset_width: 0 mm; Tile: yes; Family: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Tile Complete_Easydrain: Tile 10x10; Family and Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Tile Complete_Easydrain: Tile 10x10; s: 5 mm; Tile_Thickness_calculated: 17 mm; Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Tile Complete_Easydrain: Tile 10x10; Type Id: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Tile Complete_Easydrain: Tile 10x10; WPS Length: 330 mm
Phasing - Phase Created: New Construction
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Tile Complete_Easydrain:Tile 10x10:...) | Build-in-Depth (mm) = NLRS_C_hoogte (mm) = Build_in_depth_calculated (mm) | Mark
3935441 | 59 | 2602
3935622 | 90 | 2611 | Identity Data - Design Option: Main Model
3935708 | 59 | 2620 | Identity Data - Design Option: Main Model
3935717 | 90 | 2629
3935746 | 59 | 2638
3935755 | 90 | 2647
3935779 | 59 | 2656
3935788 | 90 | 2665 | Identity Data - Design Option: Main Model

# IfcFlowTerminal: Tile 10x10 (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_52_WPS_ EasyDrain, Roestvrijstaal,geborsteld
Type - Dimensions - Grate Length: 100 mm; Grate Width: 100 mm
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Aqua Jewels Quatro; Manufacturer: Easy Sanitary Solutions; Model: Aqua Jewels Quatro; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Tile 10x10; URL: https://www.easydrain.nl/doucheputten/aqua-jewels-quattro/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: Default
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Tile 10x10
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm; WPS: yes; Host: Level : Level 1; Tile Thickness: 5 mm
Dimensions - Flange length: 160 mm; Flange width: 160 mm; Grate Depth: 20 mm; NLRS_C_breedte: 100 mm; NLRS_C_lengte: 100 mm; Volume: 0.000469 m3
Identity Data - NLRS_C_code_product: AJQ-10X10-T; NLRS_C_omschrijving: Aqua Jewels Quatro - Tile
Other - offset_length: 0 mm; offset_width: 0 mm; Family: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Tile 10x10; Family and Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Tile 10x10; s: 5 mm; Tile: no; Tile_Thickness_calculated: 5 mm; Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Tile 10x10; Type Id: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Tile 10x10; WPS Length: 330 mm
Phasing - Phase Created: New Construction
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain:Tile 10x10:...) | Build-in-Depth (mm) = NLRS_C_hoogte (mm) = Build_in_depth_calculated (mm) | Mark
3053112 | 59 | 1063 | Identity Data - Design Option: Main Model
3053444 | 90 | 1162 | Identity Data - Design Option: Main Model
3060092 | 59 | 1334
3060137 | 90 | 1379
3064952 | 59 | 1618
3064997 | 90 | 1663
3083454 | 59 | 2043
3083499 | 90 | 2088

# IfcFlowTerminal: Tile 15x15 (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_52_WPS_ EasyDrain, Default, NLRS_h2_RVS_geborsteld
Type - Dimensions - Grate Length: 150 mm; Grate Width: 150 mm
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Aqua Jewels Quatro voor Natuursteen; Manufacturer: Easy Sanitary Solutions; Model: Aqua Jewels Quatro; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Tile 15x15; URL: http://www.easydrain.com/linear-shower-drains/series/modulo-design/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: Default
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Tile Complete_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Tile 15x15
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm; WPS: yes; Host: Level : Level 1; Tile Thickness: 17 mm
Dimensions - Flange length: 210 mm; Flange width: 210 mm; Grate Depth: 20 mm; NLRS_C_breedte: 150 mm; NLRS_C_lengte: 150 mm; Volume: 0.0010926 m3
Identity Data - NLRS_C_code_product: AJQ-15X15-T-HOOG; NLRS_C_omschrijving: Aqua Jewels Quatro - Tile for Natural Stone
Other - Tile: yes; Family: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Tile Complete_Easydrain: Tile 15x15; Family and Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Tile Complete_Easydrain: Tile 15x15; offset_length: 5 mm; offset_width: 10 mm; s: 5 mm; Tile_Thickness_calculated: 17 mm; Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Tile Complete_Easydrain: Tile 15x15; Type Id: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Tile Complete_Easydrain: Tile 15x15; WPS Length: 330 mm
Phasing - Phase Created: New Construction
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Tile Complete_Easydrain:Tile 15x15:...) | Build-in-Depth (mm) = NLRS_C_hoogte (mm) = Build_in_depth_calculated (mm) | Mark
3935566 | 59 | 2605 | Identity Data - Design Option: Main Model
3935625 | 90 | 2614 | Identity Data - Design Option: Main Model
3935711 | 59 | 2623
3935720 | 90 | 2632
3935749 | 59 | 2641
3935758 | 90 | 2650 | Identity Data - Design Option: Main Model
3935782 | 59 | 2659
3935791 | 90 | 2668

# IfcFlowTerminal: Tile 15x15 (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_52_WPS_ EasyDrain, Roestvrijstaal,geborsteld
Type - Dimensions - Grate Length: 150 mm; Grate Width: 150 mm
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Aqua Jewels Quatro; Manufacturer: Easy Sanitary Solutions; Model: Aqua Jewels Quatro; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Tile 15x15; URL: https://www.easydrain.nl/doucheputten/aqua-jewels-quattro/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: Default
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Tile 15x15
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm; WPS: yes; Host: Level : Level 1; Tile Thickness: 5 mm
Dimensions - Flange length: 210 mm; Flange width: 210 mm; Grate Depth: 20 mm; NLRS_C_breedte: 150 mm; NLRS_C_lengte: 150 mm; Volume: 0.000756 m3
Identity Data - NLRS_C_code_product: AJQ-15X15-T; NLRS_C_omschrijving: Aqua Jewels Quatro - Tile
Other - Tile: no; Family: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Tile 15x15; Family and Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Tile 15x15; offset_length: 5 mm; offset_width: 10 mm; s: 5 mm; Tile_Thickness_calculated: 5 mm; Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Tile 15x15; Type Id: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Tile 15x15; WPS Length: 330 mm
Phasing - Phase Created: New Construction
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain:Tile 15x15:...) | Build-in-Depth (mm) = NLRS_C_hoogte (mm) = Build_in_depth_calculated (mm) | Mark
3053115 | 59 | 1066 | Identity Data - Design Option: Main Model
3053447 | 90 | 1165
3060095 | 59 | 1337 | Identity Data - Design Option: Main Model
3060140 | 90 | 1382 | Identity Data - Design Option: Main Model
3064955 | 59 | 1621
3065000 | 90 | 1666 | Identity Data - Design Option: Main Model
3083457 | 59 | 2046
3083502 | 90 | 2091

# IfcFlowTerminal: Tile 20x20 (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_52_WPS_ EasyDrain, Default, NLRS_h2_RVS_geborsteld
Type - Dimensions - Grate Length: 200 mm; Grate Width: 200 mm
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Aqua Jewels Quatro voor Natuursteen; Manufacturer: Easy Sanitary Solutions; Model: Aqua Jewels Quatro; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Tile 20x20; URL: http://www.easydrain.com/linear-shower-drains/series/modulo-design/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: Default
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Tile Complete_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Tile 20x20
Constraints - Moves With Nearby Elements: no; Offset: 0 mm; WPS: yes; Level: Level: Level 1; Host: Level : Level 1; Tile Thickness: 17 mm
Dimensions - Flange length: 260 mm; Flange width: 260 mm; Grate Depth: 20 mm; NLRS_C_breedte: 200 mm; NLRS_C_lengte: 200 mm; Volume: 0.0017701 m3
Identity Data - NLRS_C_code_product: AJQ-20X20-T-HOOG; NLRS_C_omschrijving: Aqua Jewels Quatro - Tile for Natural Stone
Other - Tile: yes; Family: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Tile Complete_Easydrain: Tile 20x20; Family and Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Tile Complete_Easydrain: Tile 20x20; offset_length: 5 mm; offset_width: 10 mm; s: 5 mm; Tile_Thickness_calculated: 17 mm; Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Tile Complete_Easydrain: Tile 20x20; Type Id: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Tile Complete_Easydrain: Tile 20x20; WPS Length: 330 mm
Phasing - Phase Created: New Construction
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Tile Complete_Easydrain:Tile 20x20:...) | Build-in-Depth (mm) = NLRS_C_hoogte (mm) = Build_in_depth_calculated (mm) | Design Option | Mark
3935573 | 59 | Main Model | 2608
3935628 | 90 |  | 2617
3935714 | 59 | Main Model | 2626
3935723 | 90 | Main Model | 2635
3935752 | 59 | Main Model | 2644
3935761 | 90 |  | 2653
3935785 | 59 | Main Model | 2662
3935794 | 90 | Main Model | 2671

# IfcFlowTerminal: Tile 20x20 (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_52_WPS_ EasyDrain, Roestvrijstaal,geborsteld
Type - Dimensions - Grate Length: 200 mm; Grate Width: 200 mm
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Aqua Jewels Quatro; Manufacturer: Easy Sanitary Solutions; Model: Aqua Jewels Quatro; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Tile 20x20; URL: https://www.easydrain.nl/doucheputten/aqua-jewels-quattro/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: Default
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Tile 20x20
Constraints - Moves With Nearby Elements: no; Offset: 0 mm; WPS: yes; Level: Level: Level 1; Host: Level : Level 1; Tile Thickness: 5 mm
Dimensions - Flange length: 260 mm; Flange width: 260 mm; Grate Depth: 20 mm; NLRS_C_breedte: 200 mm; NLRS_C_lengte: 200 mm; Volume: 0.001153 m3
Identity Data - NLRS_C_code_product: AJQ-20X20-T; NLRS_C_omschrijving: Aqua Jewels Quatro - Tile
Other - Tile: no; Family: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Tile 20x20; Family and Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Tile 20x20; offset_length: 5 mm; offset_width: 10 mm; s: 5 mm; Tile_Thickness_calculated: 5 mm; Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Tile 20x20; Type Id: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Tile 20x20; WPS Length: 330 mm
Phasing - Phase Created: New Construction
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain:Tile 20x20:...) | Build-in-Depth (mm) = NLRS_C_hoogte (mm) = Build_in_depth_calculated (mm) | Mark | Design Option
3053118 | 59 | 1069
3053450 | 90 | 1168 | Main Model
3060098 | 59 | 1340 | Main Model
3060143 | 90 | 1385
3064958 | 59 | 1624 | Main Model
3065003 | 90 | 1669 | Main Model
3083460 | 59 | 2049
3083505 | 90 | 2094 | Main Model

# IfcFlowTerminal: Vinyl M2-35, NLRS_PF_52_UN_Vinyl_Easydrain:Vinyl M2-35:3064626
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Vinyl; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Vinyl M2-35; URL: https://www.easydrain.nl/douchegoten/vinyl/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Vinyl_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Vinyl M2-35
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Build-in-Depth: 50 mm; Grate Length: 750 mm; Host: Level : Level 1
Dimensions - Do: 40 mm; Do1: 89 mm; NLRS_C_breedte: 89 mm; NLRS_C_hoogte: 50 mm; NLRS_C_lengte: 700 mm; NLRS_P_c01_diameter: 40 mm; Volume: 0.00383841 m3
Identity Data - Design Option: Main Model; Mark: 1603; NLRS_C_code_product: EDVIN-M2- 700-35; NLRS_C_omschrijving: Vinyl
Mechanical - System Classification: Sanitary
Other - Outlet angle: 90 deg; build_in_depth calculated: 50 mm; Draingoot Depth: 30 mm; Draingoot Width: 89 mm; Drain length: 80 mm; Drains_number: 6; Drains_total length: 617 mm; Drains d2d: 20 mm; Family: NLRS_PF_52_UN_Vinyl_Easydrain: Vinyl M2-35; Family and Type: NLRS_PF_52_UN_Vinyl_Easydrain: Vinyl M2-35; Flange Width: 132 mm; Grate With: 63 mm; L_/_: 21.5 mm; Leg length: 50 mm; Length Calculated: 700 mm; M2_35_siphon: yes; M2_50_siphon: no; m2_vertical: no; max_length: 1200 mm; min_length: 700 mm; Outlet_pos_length: 25 mm; Outlet_pos_width: 25 mm; Outlet depth: 54 mm; Outlet length: 150 mm; ref_line_angle: 180 deg; Ro: 20 mm; Ro1: 44.5 mm; Siphon Depth: 54 mm; Siphon Length: 210 mm; Siphon Width: 120 mm; Tile_thickness_calculated: 5 mm; Tile Thickness: 5 mm; Type: NLRS_PF_52_UN_Vinyl_Easydrain: Vinyl M2-35; Type Id: NLRS_PF_52_UN_Vinyl_Easydrain: Vinyl M2-35
Phasing - Phase Created: New Construction

# IfcFlowTerminal: Vinyl M2-50, NLRS_PF_52_UN_Vinyl_Easydrain:Vinyl M2-50:3064747
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
