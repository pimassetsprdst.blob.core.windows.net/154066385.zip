Properties of the parts of a building model (IFC2X3), part 5 of 9

# IfcFlowTerminal: Dot zijuitloop hoog 50mm, zij-ingang 40mm, NLRS_PF_52_UN_Showerboard DOT_in_uitloop_Easydrain:Dot zijuitloop hoog 50mm, zij-ingang 40mm:3372464
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Bottom Plate: yes; Build-in-Depth: 90 mm; Host: Level : Level 1; Tile Thickness: 9 mm
Dimensions - Do: 102 mm; Do1: 50 mm; Do2: 40 mm; NLRS_C_hoogte: 90 mm; NLRS_C_lengte: 1200 mm; NLRS_P_c01_diameter: 50 mm; NLRS_P_c02_diameter: 40 mm; Volume: 0.112944 m3
Identity Data - Mark: 2544; NLRS_C_code_product: EDDOT-RD; NLRS_C_omschrijving: Shower Board DOT
Mechanical - System Classification: Sanitary
Other - siphon_angle: 90 deg; Board height: 40 mm; discharge_void_length: 1500 mm; E1: 54 mm; E2: 49 mm; Family: NLRS_PF_52_UN_Showerboard DOT_in_uitloop_Easydrain: Dot zijuitloop hoog 50mm, zij-ingang 40mm; Family and Type: NLRS_PF_52_UN_Showerboard DOT_in_uitloop_Easydrain: Dot zijuitloop hoog 50mm, zij-ingang 40mm; H_Siphon: 90 mm; Inlet Depth: 41 mm; offset_siphon: -9 mm; Outlet Depth: 36 mm; Outlet Length: 550 mm; Outlet Width: 550 mm; Showerboard baseheight: 31 mm; Showerboard Height: 50 mm; Showerboard Length: 1200 mm; Showerboard Width: 1100 mm; Siphon_inlet_length: 91 mm; Siphon_outlet_length: 91 mm; Siphon height calculated: 90 mm; Tile_thickness_check: 9 mm; Tile Diameter: 658 mm; Type: NLRS_PF_52_UN_Showerboard DOT_in_uitloop_Easydrain: Dot zijuitloop hoog 50mm, zij-ingang 40mm; Type Id: NLRS_PF_52_UN_Showerboard DOT_in_uitloop_Easydrain: Dot zijuitloop hoog 50mm, zij-ingang 40mm; Void Diameter: 676 mm
Phasing - Phase Created: New Construction

# IfcFlowTerminal: Green Glass 10x10 (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_52_WPS_ EasyDrain, NLRS_o_Glas_groen, Roestvrijstaal,geborsteld
Type - Dimensions - Grate Length: 100 mm; Grate Width: 100 mm
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Aqua Jewels Quatro; Manufacturer: Easy Sanitary Solutions; Model: Aqua Jewels Quatro; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Green Glass 10x10; URL: https://www.easydrain.nl/doucheputten/aqua-jewels-quattro/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: NLRS_o_Glas_groen
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Green Glass 10x10
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm; WPS: yes; Host: Level : Level 1; Tile Thickness: 5 mm
Dimensions - Flange length: 160 mm; Flange width: 160 mm; Grate Depth: 20 mm; NLRS_C_breedte: 100 mm; NLRS_C_lengte: 100 mm; Volume: 0.0005105 m3
Identity Data - NLRS_C_code_product: AJQ-10X10-GG; NLRS_C_omschrijving: Aqua Jewels Quatro - Green Glass
Other - offset_length: 0 mm; offset_width: 0 mm; Tile: yes; Family: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Green Glass 10x10; Family and Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Green Glass 10x10; s: 5 mm; Tile_Thickness_calculated: 5 mm; Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Green Glass 10x10; Type Id: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Green Glass 10x10; WPS Length: 330 mm
Phasing - Phase Created: New Construction
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain:Green Glass 10x10:...) | Build-in-Depth (mm) = NLRS_C_hoogte (mm) = Build_in_depth_calculated (mm) | Mark
3053162 | 59 | 1090
3053471 | 90 | 1189
3060119 | 59 | 1361
3060164 | 90 | 1406 | Identity Data - Design Option: Main Model
3064979 | 59 | 1645 | Identity Data - Design Option: Main Model
3065024 | 90 | 1690 | Identity Data - Design Option: Main Model
3083481 | 59 | 2070 | Identity Data - Design Option: Main Model
3083526 | 90 | 2115

# IfcFlowTerminal: Green Glass 15x15 (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_52_WPS_ EasyDrain, NLRS_o_Glas_groen, Roestvrijstaal,geborsteld
Type - Dimensions - Grate Length: 150 mm; Grate Width: 150 mm
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Aqua Jewels Quatro; Manufacturer: Easy Sanitary Solutions; Model: Aqua Jewels Quatro; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Green Glass 15x15; URL: https://www.easydrain.nl/doucheputten/aqua-jewels-quattro/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: NLRS_o_Glas_groen
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Green Glass 15x15
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm; WPS: yes; Host: Level : Level 1; Tile Thickness: 5 mm
Dimensions - Flange length: 210 mm; Flange width: 210 mm; Grate Depth: 20 mm; NLRS_C_breedte: 150 mm; NLRS_C_lengte: 150 mm; Volume: 0.000855 m3
Identity Data - NLRS_C_code_product: AJQ-15X15-GG; NLRS_C_omschrijving: Aqua Jewels Quatro - Green Glass
Other - Tile: yes; Family: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Green Glass 15x15; Family and Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Green Glass 15x15; offset_length: 5 mm; offset_width: 10 mm; s: 5 mm; Tile_Thickness_calculated: 5 mm; Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Green Glass 15x15; Type Id: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Green Glass 15x15; WPS Length: 330 mm
Phasing - Phase Created: New Construction
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain:Green Glass 15x15:...) | Build-in-Depth (mm) = NLRS_C_hoogte (mm) = Build_in_depth_calculated (mm) | Mark
3053165 | 59 | 1093 | Identity Data - Design Option: Main Model
3053474 | 90 | 1192
3060122 | 59 | 1364
3060167 | 90 | 1409
3064982 | 59 | 1648 | Identity Data - Design Option: Main Model
3065027 | 90 | 1693
3083484 | 59 | 2073 | Identity Data - Design Option: Main Model
3083529 | 90 | 2118 | Identity Data - Design Option: Main Model

# IfcFlowTerminal: Green Glass 20x20 (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_52_WPS_ EasyDrain, NLRS_o_Glas_groen, Roestvrijstaal,geborsteld
Type - Dimensions - Grate Length: 200 mm; Grate Width: 200 mm
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Aqua Jewels Quatro; Manufacturer: Easy Sanitary Solutions; Model: Aqua Jewels Quatro; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Green Glass 20x20; URL: https://www.easydrain.nl/doucheputten/aqua-jewels-quattro/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: NLRS_o_Glas_groen
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Green Glass 20x20
Constraints - Moves With Nearby Elements: no; Offset: 0 mm; WPS: yes; Level: Level: Level 1; Host: Level : Level 1; Tile Thickness: 5 mm
Dimensions - Flange length: 260 mm; Flange width: 260 mm; Grate Depth: 20 mm; NLRS_C_breedte: 200 mm; NLRS_C_lengte: 200 mm; Volume: 0.0013345 m3
Identity Data - NLRS_C_code_product: AJQ-20X20-GG; NLRS_C_omschrijving: Aqua Jewels Quatro - Green Glass
Other - Tile: yes; Family: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Green Glass 20x20; Family and Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Green Glass 20x20; offset_length: 5 mm; offset_width: 10 mm; s: 5 mm; Tile_Thickness_calculated: 5 mm; Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Green Glass 20x20; Type Id: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Green Glass 20x20; WPS Length: 330 mm
Phasing - Phase Created: New Construction
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain:Green Glass 20x20:...) | Build-in-Depth (mm) = NLRS_C_hoogte (mm) = Build_in_depth_calculated (mm) | Mark | Design Option
3053168 | 59 | 1096
3053477 | 90 | 1195 | Main Model
3060125 | 59 | 1367 | Main Model
3060170 | 90 | 1412
3064985 | 59 | 1651
3065030 | 90 | 1696 | Main Model
3083487 | 59 | 2076 | Main Model
3083532 | 90 | 2121 | Main Model

# IfcFlowTerminal: M-Line (12)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, Default
Type - General - NLRS_C_content_creator: Itannex bv; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: M-Line; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: M-Line; URL: https://www.easydrain.nl/douchegoten/m-line/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_M-Line_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: M-Line
Constraints - Level: Level: Level 1; Offset: 0 mm; Grate Length: 700 mm; Host: Level : Level 1; Tile Thickness: 7 mm
Dimensions - NLRS_C_breedte: 70 mm; NLRS_C_lengte: 700 mm
Identity Data - NLRS_C_omschrijving: M-Line
Mechanical - System Classification: Sanitary
Other - Discharge_center: 0 mm; Family: NLRS_PF_52_UN_M-Line_Easydrain: M-Line; Family and Type: NLRS_PF_52_UN_M-Line_Easydrain: M-Line; Flange Width: 100 mm; Length_calculated: 660 mm; max_length: 1200 mm; s: 3 mm; Tile_thickness_calculated: 7 mm; Type: NLRS_PF_52_UN_M-Line_Easydrain: M-Line; Type Id: NLRS_PF_52_UN_M-Line_Easydrain: M-Line; Wallprofile: yes
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_M-Line_Easydrain:M-Line:...) | Tile | Zero | Waterseal 30mm | Waterseal 50mm | NLRS_C_hoogte (mm) | NLRS_P_c01_diameter (mm) | Volume (m3) | Mark | NLRS_C_code_product | Capacity Waterseal (m3/s) | product_index | Build-in-Depth (mm) | Height_LR (mm) | Outlet Depth (mm) | ro (mm)
3374400 | no | yes | yes | no | 70 | 40 | 0.0015974 | 2578 | M-line- 700-30 | 0.032 | 1 | 63 | 43 | 38 | 20 | Identity Data - Design Option: Main Model
3374480 | no | yes | no | yes | 90 | 50 | 0.00201805 | 2579 | M-line- 700-50 | 0.042 | 6 | 83 | 63 | 48 | 25
3374618 | yes | no | yes | no | 70 | 40 | 0.0015974 | 2580 | M-line- 700-30 | 0.032 | 1 | 63 | 43 | 38 | 20 | Identity Data - Design Option: Main Model
3374652 | yes | no | no | yes | 90 | 50 | 0.00201805 | 2581 | M-line- 700-50 | 0.042 | 6 | 83 | 63 | 48 | 25 | Identity Data - Design Option: Main Model
3374818 | no | yes | yes | no | 70 | 40 | 0.0015974 | 2582 | M-line- 700-30 | 0.032 | 1 | 63 | 43 | 38 | 20
3374819 | no | yes | no | yes | 90 | 50 | 0.00201805 | 2583 | M-line- 700-50 | 0.042 | 6 | 83 | 63 | 48 | 25
3374820 | yes | no | yes | no | 70 | 40 | 0.0015974 | 2584 | M-line- 700-30 | 0.032 | 1 | 63 | 43 | 38 | 20 | Identity Data - Design Option: Main Model
3374821 | yes | no | no | yes | 90 | 50 | 0.00201805 | 2585 | M-line- 700-50 | 0.042 | 6 | 83 | 63 | 48 | 25 | Identity Data - Design Option: Main Model
3374886 | no | yes | yes | no | 70 | 40 | 0.0015974 | 2586 | M-line- 700-30 | 0.032 | 1 | 63 | 43 | 38 | 20
3374894 | no | yes | no | yes | 90 | 50 | 0.00201805 | 2587 | M-line- 700-50 | 0.042 | 6 | 83 | 63 | 48 | 25
3374904 | yes | no | yes | no | 70 | 40 | 0.0015974 | 2588 | M-line- 700-30 | 0.032 | 1 | 63 | 43 | 38 | 20 | Identity Data - Design Option: Main Model
3374926 | yes | no | no | yes | 90 | 50 | 0.00201805 | 2589 | M-line- 700-50 | 0.042 | 6 | 83 | 63 | 48 | 25

# IfcFlowTerminal: M2 Flat Siphon (13)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat)
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: M-2 Ondiep Sifonhuis; Manufacturer: Easy Sanitary Solutions; Model: Accessoiries; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: M2 Flat Siphon; URL: https://www.easydrain.nl/accessories/m2-ondiep-sifonhuis-nano-xs/
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: Z_DO_NOT_USE_NLRS_PF_52_UN_M2 Flat Siphon_Easydrain_XS NANO
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: M2 Flat Siphon
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Host: Level : Level 1; Offset: -5 mm; uitlaat_orientatie: 0 deg
Dimensions - Area: 0.0338915 m2; Do: 40 mm; Do1: 40 mm; inlaat_diameter: 70 mm; NLRS_C_diameter: 40 mm; NLRS_C_hoogte: 50 mm; NLRS_C_lengte: 210 mm; NLRS_P_c01_diameter: 40 mm; sifon_diameter: 120 mm; sifon_hoogte: 74 mm; sifon_lengte: 210 mm; sifonhuis_hoogte: 50 mm; Volume: 0.000689214 m3
Identity Data - NLRS_C_code_product: SPANAN01; NLRS_C_omschrijving: M2 Ondiep Sifonhuis
Other - Family: Z_DO_NOT_USE_NLRS_PF_52_UN_M2 Flat Siphon_Easydrain_XS NANO: M2 Flat Siphon; Family and Type: Z_DO_NOT_USE_NLRS_PF_52_UN_M2 Flat Siphon_Easydrain_XS NANO: M2 Flat Siphon; Ro: 20 mm; Ro2: 35 mm; Type: Z_DO_NOT_USE_NLRS_PF_52_UN_M2 Flat Siphon_Easydrain_XS NANO: M2 Flat Siphon; Type Id: Z_DO_NOT_USE_NLRS_PF_52_UN_M2 Flat Siphon_Easydrain_XS NANO: M2 Flat Siphon
Phasing - Phase Created: New Construction
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_M2 Flat Siphon_Easydrain_XS NANO:M2 Flat Siphon:...) | Mark
3074302 | 1937 | Identity Data - Design Option: Main Model
3074332 | 1942
3078788 | 1956
3078802 | 1958
3083190 | 1966 | Identity Data - Design Option: Main Model
3083204 | 1968
3084030 | 2382
3084035 | 2387
3084044 | 2396 | Identity Data - Design Option: Main Model
3084046 | 2398
3084054 | 2406 | Identity Data - Design Option: Main Model
3084056 | 2408
3962057 | 2702 | Identity Data - Design Option: Main Model

# IfcFlowTerminal: M2 Flat Siphon (2)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat)
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: M-2 Ondiep Sifonhuis; Manufacturer: Easy Sanitary Solutions; Model: Accessoiries; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: M2 Flat Siphon; URL: https://www.easydrain.nl/accessories/m2-ondiep-sifonhuis-s-line/
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: Z_DO_NOT_USE_NLRS_PF_52_UN_M2 Flat Siphon_Easydrain_S-Line Waterstop
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: M2 Flat Siphon
Constraints - Moves With Nearby Elements: no; Level: Level: Level 1; uitlaat_orientatie: 0 deg; Host: Level : Level 1
Dimensions - Area: 0.0264864 m2; Do: 50 mm; Do1: 40 mm; Do3: 120 mm; NLRS_C_diameter: 50 mm; NLRS_C_hoogte: 50 mm; NLRS_C_lengte: 210 mm; NLRS_P_c01_diameter: 40 mm; sifon_hoogte: 70 mm; sifon_lengte: 210 mm; sifonhuis_hoogte: 50 mm; Volume: 0.000679622 m3
Identity Data - Design Option: Main Model; NLRS_C_code_product: SPAMOD14; NLRS_C_omschrijving: M2 Ondiep Sifonhuis
Other - Family: Z_DO_NOT_USE_NLRS_PF_52_UN_M2 Flat Siphon_Easydrain_S-Line Waterstop: M2 Flat Siphon; Family and Type: Z_DO_NOT_USE_NLRS_PF_52_UN_M2 Flat Siphon_Easydrain_S-Line Waterstop: M2 Flat Siphon; Ro: 25 mm; Type: Z_DO_NOT_USE_NLRS_PF_52_UN_M2 Flat Siphon_Easydrain_S-Line Waterstop: M2 Flat Siphon; Type Id: Z_DO_NOT_USE_NLRS_PF_52_UN_M2 Flat Siphon_Easydrain_S-Line Waterstop: M2 Flat Siphon
Phasing - Phase Created: New Construction
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_M2 Flat Siphon_Easydrain_S-Line Waterstop:M2 Flat Siphon:...) | Offset (mm) | Mark
3373585 | -23 | 2567
3374189 | -20 | 2575

# IfcFlowTerminal: M2 Trap Body (18)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat)
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: M-2 Verticaal Sifonhuis; Manufacturer: Easy Sanitary Solutions; Model: Accessoiries; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: M2 Trap Body; URL: https://www.easydrain.nl/accessories/m-2-sifonhuis-onderuitloop/
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: Z_DO_NOT_USE_NLRS_PF_52_UN_M2 Vertical Outlet_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: M2 Trap Body
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Host: Level : Level 1
Dimensions - Area: 0.0698877 m2; Do: 160 mm; Do1: 125 mm; Do2: 75 mm; Do3: 50 mm; inlaat_positie: 25 mm; NLRS_C_diameter: 125 mm; NLRS_C_hoogte: 213 mm; NLRS_P_c01_diameter: 50 mm; sifonhuis_deel1_hoogte: 118 mm; sifonhuis_deel2_hoogte: 174 mm; sifonhuis_hoogte: 213 mm; Volume: 0.00178371 m3
Identity Data - NLRS_C_code_product: EDM2-O; NLRS_C_omschrijving: M2 Verticaal Sifonhuis
Other - Family: Z_DO_NOT_USE_NLRS_PF_52_UN_M2 Vertical Outlet_Easydrain: M2 Trap Body; Family and Type: Z_DO_NOT_USE_NLRS_PF_52_UN_M2 Vertical Outlet_Easydrain: M2 Trap Body; Type: Z_DO_NOT_USE_NLRS_PF_52_UN_M2 Vertical Outlet_Easydrain: M2 Trap Body; Type Id: Z_DO_NOT_USE_NLRS_PF_52_UN_M2 Vertical Outlet_Easydrain: M2 Trap Body
Phasing - Phase Created: New Construction
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_M2 Vertical Outlet_Easydrain:M2 Trap Body:...) | inlaat_orientatie (deg) | Offset (mm) | Mark | uitlaat_positie_breedte (mm) | uitlaat_positie_lengte (mm)
3064867 | 0 | -30 | 1606 | 0 | 25 | Identity Data - Design Option: Main Model
3074312 | 0 | -29 | 1939 | 0 | 25
3074342 | 0 | -29 | 1944 | 0 | 25
3078793 | 0 | -29 | 1957 | 0 | 25 | Identity Data - Design Option: Main Model
3078807 | 0 | -29 | 1959 | 0 | 25 | Identity Data - Design Option: Main Model
3083195 | 0 | -29 | 1967 | 0 | 25
3083209 | 0 | -29 | 1969 | 0 | 25
3084032 | 0 | -29 | 2384 | 0 | 25 | Identity Data - Design Option: Main Model
3084037 | 0 | -29 | 2389 | 0 | 25
3084045 | 0 | -29 | 2397 | 0 | 25 | Identity Data - Design Option: Main Model
3084047 | 0 | -29 | 2399 | 0 | 25
3084055 | 0 | -29 | 2407 | 0 | 25
3084057 | 0 | -29 | 2409 | 0 | 25
3086366 | 0 | -24.5 | 2499 | 0 | 25 | Identity Data - Design Option: Main Model
3086607 | 0 | -24.5 | 2504 | 0 | 25
3373675 | 0 | -43 | 2569 | 0 | 25 | Identity Data - Design Option: Main Model
3374268 | 45 | -40 | 2577 | 7.32233 | 42.6777 | Identity Data - Design Option: Main Model
3962059 | 0 | -29 | 2704 | 0 | 25

# IfcFlowTerminal: M2 ondiep sifonhuis (2)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat)
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: M-2 Ondiep Sifonhuis; Manufacturer: Easy Sanitary Solutions; Model: Accessoires; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: M2 ondiep sifonhuis; URL: https://www.easydrain.nl/accessories/m2-ondiep-sifonhuis-s-line/
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: Z_DO_NOT_USE_NLRS_PF_52_UN_M2 Flat Siphon_Easydrain_S-Line
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: M2 ondiep sifonhuis
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; uitlaat_orientatie: 0 deg; Host: Level : Level 1; Offset: -4.5 mm
Dimensions - Area: 0.0264864 m2; Do: 50 mm; Do1: 40 mm; Do3: 120 mm; NLRS_C_diameter: 50 mm; NLRS_C_hoogte: 50 mm; NLRS_C_lengte: 210 mm; NLRS_P_c01_diameter: 40 mm; sifon_hoogte: 70 mm; sifon_lengte: 210 mm; sifonhuis_hoogte: 50 mm; Volume: 0.000679622 m3
Identity Data - NLRS_C_code_product: SPAMOD14; NLRS_C_omschrijving: M2 Ondiep Sifonhuis
Other - Family: Z_DO_NOT_USE_NLRS_PF_52_UN_M2 Flat Siphon_Easydrain_S-Line: M2 ondiep sifonhuis; Family and Type: Z_DO_NOT_USE_NLRS_PF_52_UN_M2 Flat Siphon_Easydrain_S-Line: M2 ondiep sifonhuis; Ro: 25 mm; Type: Z_DO_NOT_USE_NLRS_PF_52_UN_M2 Flat Siphon_Easydrain_S-Line: M2 ondiep sifonhuis; Type Id: Z_DO_NOT_USE_NLRS_PF_52_UN_M2 Flat Siphon_Easydrain_S-Line: M2 ondiep sifonhuis
Phasing - Phase Created: New Construction
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_M2 Flat Siphon_Easydrain_S-Line:M2 ondiep sifonhuis:...) | Mark
3086220 | 2497
3086521 | 2502

# IfcFlowTerminal: Multi Long Length horizontal outlet low 40mm (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Multi Long Length; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Multi Long Length horizontal outlet low 40mm; URL: https://www.easydrain.nl/douchegoten/serie/multi/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: NLRS_n1_Asfalt_bitumen
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Multi Long Length uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi Long Length horizontal outlet low 40mm
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Build-in-Depth: 59 mm; Grate Length: 1300 mm; Host: Level : Level 1
Dimensions - Do1: 40 mm; E1: 20 mm; NLRS_C_breedte: 94 mm; NLRS_C_hoogte: 79 mm; NLRS_C_lengte: 1335 mm; NLRS_P_c01_diameter: 40 mm; Volume: 0.00233344 m3; Z1: 91 mm
Identity Data - Design Option: Main Model; NLRS_C_code_product: EDM 1300; NLRS_C_omschrijving: Multi Lange Lengtes
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - product_index: 1; Outlet Angle: 90 deg; Ref line angle: 90 deg; Build_in_depth_calculated: 79 mm; Discharge Center: 650 mm; Draingoot Depth: 5 mm; Family: NLRS_PF_52_UN_Multi Long Length uitloop_Easydrain: Multi Long Length horizontal outlet low 40mm; Family and Type: NLRS_PF_52_UN_Multi Long Length uitloop_Easydrain: Multi Long Length horizontal outlet low 40mm; Flange width: 146 mm; H_Siphon: 54 mm; Leg length: 59 mm; Length calculated: 1300 mm; max_length: 2000 mm; offset_siphon: -20 mm; Outlet Depth: 39 mm; s: 2 mm; Siphon Height: 59 mm; Siphon position: 650 mm; Tile Thickness: 15 mm; Tile thickness calculated: 15 mm; Type: NLRS_PF_52_UN_Multi Long Length uitloop_Easydrain: Multi Long Length horizontal outlet low 40mm; Type Id: NLRS_PF_52_UN_Multi Long Length uitloop_Easydrain: Multi Long Length horizontal outlet low 40mm; Waterseal: 30 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Multi Long Length uitloop_Easydrain:Multi Long Length horizontal outlet low 40mm:...) | Mark
3070456 | 1896
3083951 | 2351

# IfcFlowTerminal: Multi Long Length zijuitloop hoog 50mm, zij-ingang 40mm (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Multi Long Length; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Multi Long Length zijuitloop hoog 50mm, zij-ingang 40mm; URL: https://www.easydrain.nl/douchegoten/serie/multi/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: NLRS_n1_Asfalt_bitumen
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Multi Long Length in_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi Long Length zijuitloop hoog 50mm, zij-ingang 40mm
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Build-in-Depth: 90 mm; Grate Length: 1300 mm; Host: Level : Level 1
Dimensions - Do1: 50 mm; Do2: 40 mm; E1: 54 mm; E2: 49 mm; NLRS_C_breedte: 94 mm; NLRS_C_hoogte: 110 mm; NLRS_C_lengte: 1335 mm; NLRS_P_c01_diameter: 50 mm; NLRS_P_c02_diameter: 40 mm; Volume: 0.00233504 m3; Z1: 91 mm
Identity Data - Design Option: Main Model; NLRS_C_code_product: EDM 1300; NLRS_C_omschrijving: Multi Lange Lengtes
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - product_index: 1; Outlet Angle: 90 deg; Ref line angle: 90 deg; Build_in_depth_calculated: 110 mm; Discharge Center: 650 mm; Draingoot Depth: 5 mm; Family: NLRS_PF_52_UN_Multi Long Length in_uitloop_Easydrain: Multi Long Length zijuitloop hoog 50mm, zij-ingang 40mm; Family and Type: NLRS_PF_52_UN_Multi Long Length in_uitloop_Easydrain: Multi Long Length zijuitloop hoog 50mm, zij-ingang 40mm; H_Siphon: 90 mm; Inlet Depth: 41 mm; Inlet Length: 91 mm; Leg length: 90 mm; Length calculated: 1300 mm; max_length: 2000 mm; offset_siphon: -20 mm; Outlet Depth: 36 mm; s: 2 mm; Siphon Height: 90 mm; Siphon position: 650 mm; Tile Thickness: 15 mm; Tile thickness calculated: 15 mm; Type: NLRS_PF_52_UN_Multi Long Length in_uitloop_Easydrain: Multi Long Length zijuitloop hoog 50mm, zij-ingang 40mm; Type Id: NLRS_PF_52_UN_Multi Long Length in_uitloop_Easydrain: Multi Long Length zijuitloop hoog 50mm, zij-ingang 40mm; Waterseal: 50 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Multi Long Length in_uitloop_Easydrain:Multi Long Length zijuitloop hoog 50mm, zij-ingang 40mm:...) | Mark
3070536 | 1898
3083953 | 2353

# IfcFlowTerminal: Multi Square horizontal outlet low 40mm (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Multi Square; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Multi Square horizontal outlet low 40mm; URL: https://www.easydrain.nl/douchegoten/square-multi/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Multi Square uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi Square horizontal outlet low 40mm
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Build-in-Depth: 59 mm; Host: Level : Level 1; Square 1000x1000mm: no; Square 900x900mm: yes
Dimensions - Do1: 40 mm; E1: 20 mm; Grate Length: 900 mm; NLRS_C_breedte: 900 mm; NLRS_C_hoogte: 59 mm; NLRS_C_lengte: 900 mm; NLRS_P_c01_diameter: 40 mm; Volume: 0.003347 m3; Z1: 91 mm
Identity Data - NLRS_C_code_product: EDMHOEK900; NLRS_C_omschrijving: Multi Square
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Outlet angle: 90 deg; Build_in_depth_calculated: 59 mm; Draingoot Depth: 20 mm; Family: NLRS_PF_52_UN_Multi Square uitloop_Easydrain: Multi Square horizontal outlet low 40mm; Family and Type: NLRS_PF_52_UN_Multi Square uitloop_Easydrain: Multi Square horizontal outlet low 40mm; H_Siphon: 54 mm; Outlet Depth: 39 mm; ref line angle: 90 deg; Siphon Height: 59 mm; Type: NLRS_PF_52_UN_Multi Square uitloop_Easydrain: Multi Square horizontal outlet low 40mm; Type Id: NLRS_PF_52_UN_Multi Square uitloop_Easydrain: Multi Square horizontal outlet low 40mm; Waterseal: 30 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Multi Square uitloop_Easydrain:Multi Square horizontal outlet low 40mm:...) | Mark
3072497 | 1916
3083985 | 2367

# IfcFlowTerminal: Multi Square zijuitloop hoog 50mm, zij-ingang 40mm (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Multi Square; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Multi Square zijuitloop hoog 50mm, zij-ingang 40mm; URL: https://www.easydrain.nl/douchegoten/square-multi/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Multi Square in_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi Square zijuitloop hoog 50mm, zij-ingang 40mm
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Square 1000x1000mm: no; Square 900x900mm: yes; Build-in-Depth: 59 mm; Host: Level : Level 1
Dimensions - Do1: 50 mm; Do2: 40 mm; E1: 54 mm; E2: 49 mm; Grate Length: 900 mm; NLRS_C_breedte: 900 mm; NLRS_C_hoogte: 59 mm; NLRS_C_lengte: 900 mm; NLRS_P_c01_diameter: 50 mm; NLRS_P_c02_diameter: 40 mm; Volume: 0.003347 m3; Z1: 91 mm
Identity Data - Design Option: Main Model; NLRS_C_code_product: EDMHOEK900; NLRS_C_omschrijving: Multi Square
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Outlet angle: 90 deg; ref line angle: 90 deg; Build_in_depth_calculated: 59 mm; Draingoot Depth: 20 mm; Family: NLRS_PF_52_UN_Multi Square in_uitloop_Easydrain: Multi Square zijuitloop hoog 50mm, zij-ingang 40mm; Family and Type: NLRS_PF_52_UN_Multi Square in_uitloop_Easydrain: Multi Square zijuitloop hoog 50mm, zij-ingang 40mm; H_Siphon: 90 mm; Inlet Depth: 41 mm; Inlet Length: 91 mm; Outlet Depth: 36 mm; Siphon Height: 90 mm; Type: NLRS_PF_52_UN_Multi Square in_uitloop_Easydrain: Multi Square zijuitloop hoog 50mm, zij-ingang 40mm; Type Id: NLRS_PF_52_UN_Multi Square in_uitloop_Easydrain: Multi Square zijuitloop hoog 50mm, zij-ingang 40mm; Waterseal: 50 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Multi Square in_uitloop_Easydrain:Multi Square zijuitloop hoog 50mm, zij-ingang 40mm:...) | Mark
3072674 | 1918
3083987 | 2369

# IfcFlowTerminal: Multi TAF Wall horizontal outlet high 50mm, NLRS_PF_52_UN_Multi TAF Wall uitloop_Easydrain:Multi TAF Wall horizontal outlet high 50mm:3085097
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Multi TAF Wall; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Multi TAF Wall horizontal outlet high 50mm; URL: https://www.easydrain.nl/douchegoten/multi-taf-wall/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: NLRS_n1_Asfalt_bitumen
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Multi TAF Wall uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi TAF Wall horizontal outlet high 50mm
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Tile: no; Zero: yes; Single Extension Set: no; Extension Set: no; Siphon Left: yes; Siphon Right: no; Build-in-Depth: 54 mm; Grate Length: 1200 mm; Host: Level : Level 1; Tile Thickness: 7 mm
Dimensions - Do1: 50 mm; E1: 54 mm; NLRS_C_breedte: 94 mm; NLRS_C_hoogte: 79 mm; NLRS_C_lengte: 1200 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.00362169 m3; Z1: 91 mm
Identity Data - Mark: 2470; NLRS_C_code_product: EDMTAFW 1200; NLRS_C_omschrijving: Multi TAF Wall
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Outlet Angle: 90 deg; Ref line angle: 90 deg; Wall Profile: yes; Build_in_depth_calculated: 79 mm; Discharge Center: 600 mm; Draingoot Depth: 20 mm; ExtensionSet_length: 17.5 mm; Family: NLRS_PF_52_UN_Multi TAF Wall uitloop_Easydrain: Multi TAF Wall horizontal outlet high 50mm; Family and Type: NLRS_PF_52_UN_Multi TAF Wall uitloop_Easydrain: Multi TAF Wall horizontal outlet high 50mm; Flange width: 146 mm; H_Siphon: 90 mm; Leg length: 59 mm; Length calculated: 1165 mm; max_length: 2000 mm; offset_siphon: -27 mm; Outlet Depth: 36 mm; product_index: 24; s: 2 mm; Siphon Height: 90 mm; Siphon position: 500 mm; Tile thickness calculated: 7 mm; Type: NLRS_PF_52_UN_Multi TAF Wall uitloop_Easydrain: Multi TAF Wall horizontal outlet high 50mm; Type Id: NLRS_PF_52_UN_Multi TAF Wall uitloop_Easydrain: Multi TAF Wall horizontal outlet high 50mm; Waterseal: 50 mm
Phasing - Phase Created: New Construction

# IfcFlowTerminal: Multi TAF Wall horizontal outlet low 40mm (4)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Multi TAF Wall; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Multi TAF Wall horizontal outlet low 40mm; URL: https://www.easydrain.nl/douchegoten/multi-taf-wall/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: NLRS_n1_Asfalt_bitumen
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Multi TAF Wall uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi TAF Wall horizontal outlet low 40mm
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Tile: no; Zero: yes; Single Extension Set: no; Extension Set: no; Siphon Left: yes; Siphon Right: no; Build-in-Depth: 54 mm; Grate Length: 1200 mm; Host: Level : Level 1; Tile Thickness: 7 mm
Dimensions - Do1: 40 mm; E1: 20 mm; NLRS_C_breedte: 94 mm; NLRS_C_hoogte: 79 mm; NLRS_C_lengte: 1200 mm; NLRS_P_c01_diameter: 40 mm; Volume: 0.00362169 m3; Z1: 91 mm
Identity Data - NLRS_C_code_product: EDMTAFW 1200; NLRS_C_omschrijving: Multi TAF Wall
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Outlet Angle: 90 deg; Ref line angle: 90 deg; Build_in_depth_calculated: 79 mm; Discharge Center: 600 mm; Draingoot Depth: 20 mm; ExtensionSet_length: 17.5 mm; Family: NLRS_PF_52_UN_Multi TAF Wall uitloop_Easydrain: Multi TAF Wall horizontal outlet low 40mm; Family and Type: NLRS_PF_52_UN_Multi TAF Wall uitloop_Easydrain: Multi TAF Wall horizontal outlet low 40mm; Flange width: 146 mm; H_Siphon: 54 mm; Leg length: 59 mm; Length calculated: 1165 mm; max_length: 2000 mm; offset_siphon: -27 mm; Outlet Depth: 34 mm; product_index: 24; s: 2 mm; Siphon Height: 54 mm; Siphon position: 500 mm; Tile thickness calculated: 7 mm; Type: NLRS_PF_52_UN_Multi TAF Wall uitloop_Easydrain: Multi TAF Wall horizontal outlet low 40mm; Type Id: NLRS_PF_52_UN_Multi TAF Wall uitloop_Easydrain: Multi TAF Wall horizontal outlet low 40mm; Wall Profile: yes; Waterseal: 30 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Multi TAF Wall uitloop_Easydrain:Multi TAF Wall horizontal outlet low 40mm:...) | Mark
3058308 | 1277
3072313 | 1910
3083979 | 2361
3084810 | 2464

# IfcFlowTerminal: Multi TAF Wall horizontal outlet low 40mm, NLRS_PF_52_UN_Multi TAF Wall uitloop_Easydrain:Multi TAF Wall horizontal outlet low 40mm:3058367
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_n1_Asfalt_bitumen, NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Multi TAF Wall; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Multi TAF Wall horizontal outlet low 40mm; URL: https://www.easydrain.nl/douchegoten/multi-taf-wall/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: NLRS_n1_Asfalt_bitumen
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Multi TAF Wall uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi TAF Wall horizontal outlet low 40mm
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Tile: yes; Zero: no; Single Extension Set: no; Extension Set: no; Siphon Left: yes; Siphon Right: no; Build-in-Depth: 54 mm; Grate Length: 1200 mm; Host: Level : Level 1; Tile Thickness: 7 mm
Dimensions - Do1: 40 mm; E1: 20 mm; NLRS_C_breedte: 94 mm; NLRS_C_hoogte: 79 mm; NLRS_C_lengte: 1200 mm; NLRS_P_c01_diameter: 40 mm; Volume: 0.00362618 m3; Z1: 91 mm
Identity Data - Design Option: Main Model; Mark: 1280; NLRS_C_code_product: EDMTAFW 1200; NLRS_C_omschrijving: Multi TAF Wall
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Outlet Angle: 90 deg; Ref line angle: 90 deg; Family: NLRS_PF_52_UN_Multi TAF Wall uitloop_Easydrain: Multi TAF Wall horizontal outlet low 40mm; Family and Type: NLRS_PF_52_UN_Multi TAF Wall uitloop_Easydrain: Multi TAF Wall horizontal outlet low 40mm; Type: NLRS_PF_52_UN_Multi TAF Wall uitloop_Easydrain: Multi TAF Wall horizontal outlet low 40mm; Type Id: NLRS_PF_52_UN_Multi TAF Wall uitloop_Easydrain: Multi TAF Wall horizontal outlet low 40mm; Wall Profile: yes; Build_in_depth_calculated: 79 mm; Discharge Center: 600 mm; Draingoot Depth: 20 mm; ExtensionSet_length: 17.5 mm; Flange width: 146 mm; H_Siphon: 54 mm; Leg length: 59 mm; Length calculated: 1165 mm; max_length: 2000 mm; offset_siphon: -27 mm; Outlet Depth: 34 mm; product_index: 24; s: 2 mm; Siphon Height: 54 mm; Siphon position: 500 mm; Tile thickness calculated: 7 mm; Waterseal: 30 mm
Phasing - Phase Created: New Construction

# IfcFlowTerminal: Multi TAF Wall horizontal outlet low 50mm, NLRS_PF_52_UN_Multi TAF Wall uitloop_Easydrain:Multi TAF Wall horizontal outlet low 50mm:3084956
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_n1_Asfalt_bitumen, NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Multi TAF Wall; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Multi TAF Wall horizontal outlet low 50mm; URL: https://www.easydrain.nl/douchegoten/multi-taf-wall/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: NLRS_n1_Asfalt_bitumen
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Multi TAF Wall uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi TAF Wall horizontal outlet low 50mm
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Tile: yes; Zero: no; Single Extension Set: no; Extension Set: no; Siphon Left: yes; Siphon Right: no; Build-in-Depth: 59 mm; Grate Length: 1200 mm; Host: Level : Level 1; Tile Thickness: 7 mm
Dimensions - Do1: 50 mm; E1: 25 mm; NLRS_C_breedte: 94 mm; NLRS_C_hoogte: 79 mm; NLRS_C_lengte: 1200 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.00362618 m3; Z1: 91 mm
Identity Data - Mark: 2467; NLRS_C_code_product: EDMTAFW 1200; NLRS_C_omschrijving: Multi TAF Wall
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Outlet Angle: 90 deg; Ref line angle: 90 deg; Wall Profile: yes; Build_in_depth_calculated: 79 mm; Discharge Center: 600 mm; Draingoot Depth: 20 mm; ExtensionSet_length: 17.5 mm; Family: NLRS_PF_52_UN_Multi TAF Wall uitloop_Easydrain: Multi TAF Wall horizontal outlet low 50mm; Family and Type: NLRS_PF_52_UN_Multi TAF Wall uitloop_Easydrain: Multi TAF Wall horizontal outlet low 50mm; Flange width: 146 mm; H_Siphon: 59 mm; Leg length: 59 mm; Length calculated: 1165 mm; max_length: 2000 mm; offset_siphon: -27 mm; Outlet Depth: 34 mm; product_index: 24; s: 2 mm; Siphon Height: 59 mm; Siphon position: 500 mm; Tile thickness calculated: 7 mm; Type: NLRS_PF_52_UN_Multi TAF Wall uitloop_Easydrain: Multi TAF Wall horizontal outlet low 50mm; Type Id: NLRS_PF_52_UN_Multi TAF Wall uitloop_Easydrain: Multi TAF Wall horizontal outlet low 50mm; Waterseal: 30 mm
Phasing - Phase Created: New Construction

# IfcFlowTerminal: Multi TAF Wall onderuitloop 50mm, zij-ingang 40mm, NLRS_PF_52_UN_Multi TAF Wall in_uitloop_Easydrain:Multi TAF Wall onderuitloop 50mm, zij-ingang 40mm:3085331
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_n1_Asfalt_bitumen, NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot verticale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Multi TAF Wall; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Multi TAF Wall onderuitloop 50mm, zij-ingang 40mm; URL: https://www.easydrain.nl/douchegoten/multi-taf-wall/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: NLRS_n1_Asfalt_bitumen
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Multi TAF Wall in_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi TAF Wall onderuitloop 50mm, zij-ingang 40mm
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Tile: yes; Zero: no; Single Extension Set: no; Extension Set: no; Siphon Left: yes; Siphon Right: no; Build-in-Depth: 90 mm; Grate Length: 1200 mm; Host: Level : Level 1; Tile Thickness: 7 mm
Dimensions - E1: 0 mm; Do1: 50 mm; Do2: 40 mm; E2: 49 mm; NLRS_C_breedte: 94 mm; NLRS_C_hoogte: 90 mm; NLRS_C_lengte: 1200 mm; NLRS_P_c01_diameter: 50 mm; NLRS_P_c02_diameter: 40 mm; Volume: 0.00362675 m3; Z1: 40 mm
Identity Data - Mark: 2479; NLRS_C_code_product: EDMTAFW 1200; NLRS_C_omschrijving: Multi TAF Wall
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Ref line angle: 90 deg; Wall Profile: yes; Outlet Angle: 180 deg; Build_in_depth_calculated: 90 mm; Discharge Center: 600 mm; Draingoot Depth: 20 mm; ExtensionSet_length: 17.5 mm; Family: NLRS_PF_52_UN_Multi TAF Wall in_uitloop_Easydrain: Multi TAF Wall onderuitloop 50mm, zij-ingang 40mm; Family and Type: NLRS_PF_52_UN_Multi TAF Wall in_uitloop_Easydrain: Multi TAF Wall onderuitloop 50mm, zij-ingang 40mm; Flange width: 146 mm; H_Siphon: 90 mm; Inlet Depth: 41 mm; Inlet Length: 91 mm; Leg length: 70 mm; Length calculated: 1165 mm; max_length: 2000 mm; offset_siphon: -27 mm; Outlet Depth: 90 mm; product_index: 24; s: 2 mm; Siphon Height: 90 mm; Siphon position: 500 mm; Tile thickness calculated: 7 mm; Type: NLRS_PF_52_UN_Multi TAF Wall in_uitloop_Easydrain: Multi TAF Wall onderuitloop 50mm, zij-ingang 40mm; Type Id: NLRS_PF_52_UN_Multi TAF Wall in_uitloop_Easydrain: Multi TAF Wall onderuitloop 50mm, zij-ingang 40mm; Waterseal: 35 mm
Phasing - Phase Created: New Construction

# IfcFlowTerminal: Multi TAF Wall onderuitloop 50mm, zij-ingang 50mm, NLRS_PF_52_UN_Multi TAF Wall in_uitloop_Easydrain:Multi TAF Wall onderuitloop 50mm, zij-ingang 50mm:3085383
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot verticale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Multi TAF Wall; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Multi TAF Wall onderuitloop 50mm, zij-ingang 50mm; URL: https://www.easydrain.nl/douchegoten/multi-taf-wall/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: NLRS_n1_Asfalt_bitumen
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Multi TAF Wall in_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi TAF Wall onderuitloop 50mm, zij-ingang 50mm
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Tile: no; Zero: yes; Single Extension Set: no; Extension Set: no; Siphon Left: yes; Siphon Right: no; Build-in-Depth: 90 mm; Grate Length: 1200 mm; Host: Level : Level 1; Tile Thickness: 7 mm
Dimensions - E1: 0 mm; Do1: 50 mm; Do2: 50 mm; E2: 54 mm; NLRS_C_breedte: 94 mm; NLRS_C_hoogte: 90 mm; NLRS_C_lengte: 1200 mm; NLRS_P_c01_diameter: 50 mm; NLRS_P_c02_diameter: 50 mm; Volume: 0.00362226 m3; Z1: 40 mm
Identity Data - Mark: 2482; NLRS_C_code_product: EDMTAFW 1200; NLRS_C_omschrijving: Multi TAF Wall
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Ref line angle: 90 deg; Wall Profile: yes; Outlet Angle: 180 deg; Build_in_depth_calculated: 90 mm; Discharge Center: 600 mm; Draingoot Depth: 20 mm; ExtensionSet_length: 17.5 mm; Family: NLRS_PF_52_UN_Multi TAF Wall in_uitloop_Easydrain: Multi TAF Wall onderuitloop 50mm, zij-ingang 50mm; Family and Type: NLRS_PF_52_UN_Multi TAF Wall in_uitloop_Easydrain: Multi TAF Wall onderuitloop 50mm, zij-ingang 50mm; Flange width: 146 mm; H_Siphon: 90 mm; Inlet Depth: 36 mm; Inlet Length: 91 mm; Leg length: 70 mm; Length calculated: 1165 mm; max_length: 2000 mm; offset_siphon: -27 mm; Outlet Depth: 90 mm; product_index: 24; s: 2 mm; Siphon Height: 90 mm; Siphon position: 500 mm; Tile thickness calculated: 7 mm; Type: NLRS_PF_52_UN_Multi TAF Wall in_uitloop_Easydrain: Multi TAF Wall onderuitloop 50mm, zij-ingang 50mm; Type Id: NLRS_PF_52_UN_Multi TAF Wall in_uitloop_Easydrain: Multi TAF Wall onderuitloop 50mm, zij-ingang 50mm; Waterseal: 35 mm
Phasing - Phase Created: New Construction

# IfcFlowTerminal: Multi TAF Wall vertical outlet 50mm, NLRS_PF_52_UN_Multi TAF Wall uitloop_Easydrain:Multi TAF Wall vertical outlet 50mm:3085197
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_n1_Asfalt_bitumen, NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot verticale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Multi TAF Wall; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Multi TAF Wall vertical outlet 50mm; URL: https://www.easydrain.nl/douchegoten/multi-taf-wall/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: NLRS_n1_Asfalt_bitumen
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Multi TAF Wall uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi TAF Wall vertical outlet 50mm
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Tile: yes; Zero: no; Single Extension Set: no; Extension Set: no; Siphon Left: yes; Siphon Right: no; Build-in-Depth: 59 mm; Grate Length: 1200 mm; Host: Level : Level 1; Tile Thickness: 7 mm
Dimensions - E1: 0 mm; Do1: 50 mm; NLRS_C_breedte: 94 mm; NLRS_C_hoogte: 79 mm; NLRS_C_lengte: 1200 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.00362618 m3; Z1: 40 mm
Identity Data - Mark: 2473; NLRS_C_code_product: EDMTAFW 1200; NLRS_C_omschrijving: Multi TAF Wall
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Ref line angle: 90 deg; Wall Profile: yes; Build_in_depth_calculated: 79 mm; Discharge Center: 600 mm; Draingoot Depth: 20 mm; ExtensionSet_length: 17.5 mm; Family: NLRS_PF_52_UN_Multi TAF Wall uitloop_Easydrain: Multi TAF Wall vertical outlet 50mm; Family and Type: NLRS_PF_52_UN_Multi TAF Wall uitloop_Easydrain: Multi TAF Wall vertical outlet 50mm; Flange width: 146 mm; H_Siphon: 90 mm; Leg length: 59 mm; Length calculated: 1165 mm; max_length: 2000 mm; offset_siphon: -27 mm; Outlet Angle: 180 deg; Outlet Depth: 90 mm; product_index: 24; s: 2 mm; Siphon Height: 90 mm; Siphon position: 500 mm; Tile thickness calculated: 7 mm; Type: NLRS_PF_52_UN_Multi TAF Wall uitloop_Easydrain: Multi TAF Wall vertical outlet 50mm; Type Id: NLRS_PF_52_UN_Multi TAF Wall uitloop_Easydrain: Multi TAF Wall vertical outlet 50mm; Waterseal: 35 mm
Phasing - Phase Created: New Construction

# IfcFlowTerminal: Multi TAF Wall zijuitloop hoog 50mm, zij-ingang 40mm (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Multi TAF Wall; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Multi TAF Wall zijuitloop hoog 50mm, zij-ingang 40mm; URL: https://www.easydrain.nl/douchegoten/multi-taf-wall/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: NLRS_n1_Asfalt_bitumen
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Multi TAF Wall in_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi TAF Wall zijuitloop hoog 50mm, zij-ingang 40mm
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Tile: no; Zero: yes; Single Extension Set: no; Extension Set: no; Siphon Left: yes; Siphon Right: no; Build-in-Depth: 90 mm; Grate Length: 1200 mm; Host: Level : Level 1; Tile Thickness: 7 mm
Dimensions - Do1: 50 mm; Do2: 40 mm; E1: 54 mm; E2: 49 mm; NLRS_C_breedte: 94 mm; NLRS_C_hoogte: 90 mm; NLRS_C_lengte: 1200 mm; NLRS_P_c01_diameter: 50 mm; NLRS_P_c02_diameter: 40 mm; Volume: 0.00362226 m3; Z1: 91 mm
Identity Data - NLRS_C_code_product: EDMTAFW 1200; NLRS_C_omschrijving: Multi TAF Wall
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Outlet Angle: 90 deg; Ref line angle: 90 deg; Wall Profile: yes; Build_in_depth_calculated: 90 mm; Discharge Center: 600 mm; Draingoot Depth: 20 mm; ExtensionSet_length: 17.5 mm; Family: NLRS_PF_52_UN_Multi TAF Wall in_uitloop_Easydrain: Multi TAF Wall zijuitloop hoog 50mm, zij-ingang 40mm; Family and Type: NLRS_PF_52_UN_Multi TAF Wall in_uitloop_Easydrain: Multi TAF Wall zijuitloop hoog 50mm, zij-ingang 40mm; Flange width: 146 mm; H_Siphon: 90 mm; Inlet Depth: 41 mm; Inlet Length: 91 mm; Leg length: 70 mm; Length calculated: 1165 mm; max_length: 2000 mm; offset_siphon: -27 mm; Outlet Depth: 36 mm; product_index: 24; s: 2 mm; Siphon Height: 90 mm; Siphon position: 500 mm; Tile thickness calculated: 7 mm; Type: NLRS_PF_52_UN_Multi TAF Wall in_uitloop_Easydrain: Multi TAF Wall zijuitloop hoog 50mm, zij-ingang 40mm; Type Id: NLRS_PF_52_UN_Multi TAF Wall in_uitloop_Easydrain: Multi TAF Wall zijuitloop hoog 50mm, zij-ingang 40mm; Waterseal: 50 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Multi TAF Wall in_uitloop_Easydrain:Multi TAF Wall zijuitloop hoog 50mm, zij-ingang 40mm:...) | Mark
3058724 | 1289
3085259 | 2476

# IfcFlowTerminal: Multi TAF Wall zijuitloop hoog 50mm, zij-ingang 40mm (3)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_n1_Asfalt_bitumen, NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Multi TAF Wall; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Multi TAF Wall zijuitloop hoog 50mm, zij-ingang 40mm; URL: https://www.easydrain.nl/douchegoten/multi-taf-wall/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: NLRS_n1_Asfalt_bitumen
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Multi TAF Wall in_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi TAF Wall zijuitloop hoog 50mm, zij-ingang 40mm
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Tile: yes; Level: Level: Level 1; Zero: no; Single Extension Set: no; Extension Set: no; Siphon Left: yes; Siphon Right: no; Build-in-Depth: 90 mm; Grate Length: 1200 mm; Host: Level : Level 1; Tile Thickness: 7 mm
Dimensions - Do1: 50 mm; Do2: 40 mm; E1: 54 mm; E2: 49 mm; NLRS_C_breedte: 94 mm; NLRS_C_hoogte: 90 mm; NLRS_C_lengte: 1200 mm; NLRS_P_c01_diameter: 50 mm; NLRS_P_c02_diameter: 40 mm; Volume: 0.00362675 m3; Z1: 91 mm
Identity Data - Design Option: Main Model; NLRS_C_code_product: EDMTAFW 1200; NLRS_C_omschrijving: Multi TAF Wall
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Outlet Angle: 90 deg; Ref line angle: 90 deg; Wall Profile: yes; Family: NLRS_PF_52_UN_Multi TAF Wall in_uitloop_Easydrain: Multi TAF Wall zijuitloop hoog 50mm, zij-ingang 40mm; Family and Type: NLRS_PF_52_UN_Multi TAF Wall in_uitloop_Easydrain: Multi TAF Wall zijuitloop hoog 50mm, zij-ingang 40mm; Type: NLRS_PF_52_UN_Multi TAF Wall in_uitloop_Easydrain: Multi TAF Wall zijuitloop hoog 50mm, zij-ingang 40mm; Type Id: NLRS_PF_52_UN_Multi TAF Wall in_uitloop_Easydrain: Multi TAF Wall zijuitloop hoog 50mm, zij-ingang 40mm; Build_in_depth_calculated: 90 mm; Discharge Center: 600 mm; Draingoot Depth: 20 mm; ExtensionSet_length: 17.5 mm; Flange width: 146 mm; H_Siphon: 90 mm; Inlet Depth: 41 mm; Inlet Length: 91 mm; Leg length: 70 mm; Length calculated: 1165 mm; max_length: 2000 mm; offset_siphon: -27 mm; Outlet Depth: 36 mm; product_index: 24; s: 2 mm; Siphon Height: 90 mm; Siphon position: 500 mm; Tile thickness calculated: 7 mm; Waterseal: 50 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Multi TAF Wall in_uitloop_Easydrain:Multi TAF Wall zijuitloop hoog 50mm, zij-ingang 40mm:...) | Mark
3058727 | 1292
3072389 | 1913
3083982 | 2364

# IfcFlowTerminal: Multi TAF horizontal outlet low 40mm (3)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Multi TAF; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Multi TAF horizontal outlet low 40mm; URL: https://www.easydrain.nl/douchegoten/multi-taf/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: NLRS_n1_Asfalt_bitumen
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Multi TAF uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi TAF horizontal outlet low 40mm
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Tile: no; Zero: yes; Single Extension Set: no; Extension Set: no; Build-in-Depth: 54 mm; Grate Length: 1200 mm; Host: Level : Level 1; Siphon Left: yes; Siphon Right: no; Tile Thickness: 7 mm
Dimensions - Do1: 40 mm; E1: 20 mm; NLRS_C_breedte: 94 mm; NLRS_C_hoogte: 79 mm; NLRS_C_lengte: 1200 mm; NLRS_P_c01_diameter: 40 mm; Volume: 0.00365522 m3; Z1: 91 mm
Identity Data - NLRS_C_code_product: EDMTAF 1200; NLRS_C_omschrijving: Multi TAF
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
