Properties of the parts of a building model (IFC2X3), part 6 of 9

# IfcFlowTerminal: Multi TAF horizontal outlet low 40mm (3)
Other - Build_in_depth_calculated: 79 mm; Discharge Center: 600 mm; Draingoot Depth: 20 mm; ExtensionSet_length: 17.5 mm; Family: NLRS_PF_52_UN_Multi TAF uitloop_Easydrain: Multi TAF horizontal outlet low 40mm; Family and Type: NLRS_PF_52_UN_Multi TAF uitloop_Easydrain: Multi TAF horizontal outlet low 40mm; Flange width: 146 mm; H_Siphon: 54 mm; Leg length: 59 mm; Length calculated: 1165 mm; max_length: 2000 mm; offset_siphon: -27 mm; Outlet Angle: 90 deg; Outlet Depth: 34 mm; product_index: 8; Ref line angle: 90 deg; s: 2 mm; Siphon Height: 54 mm; Siphon position: 500 mm; Tile thickness calculated: 7 mm; Type: NLRS_PF_52_UN_Multi TAF uitloop_Easydrain: Multi TAF horizontal outlet low 40mm; Type Id: NLRS_PF_52_UN_Multi TAF uitloop_Easydrain: Multi TAF horizontal outlet low 40mm; Wall Profile: no; Waterseal: 30 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Multi TAF uitloop_Easydrain:Multi TAF horizontal outlet low 40mm:...) | Mark
3058130 | 1271
3072080 | 1904 | Identity Data - Design Option: Main Model
3083973 | 2355

# IfcFlowTerminal: Multi TAF horizontal outlet low 40mm, NLRS_PF_52_UN_Multi TAF uitloop_Easydrain:Multi TAF horizontal outlet low 40mm:3058213
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_n1_Asfalt_bitumen, NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Multi TAF; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Multi TAF horizontal outlet low 40mm; URL: https://www.easydrain.nl/douchegoten/multi-taf/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: NLRS_n1_Asfalt_bitumen
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Multi TAF uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi TAF horizontal outlet low 40mm
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Tile: yes; Zero: no; Single Extension Set: no; Extension Set: no; Siphon Left: yes; Siphon Right: no; Build-in-Depth: 54 mm; Grate Length: 1200 mm; Host: Level : Level 1; Tile Thickness: 7 mm
Dimensions - Do1: 40 mm; E1: 20 mm; NLRS_C_breedte: 94 mm; NLRS_C_hoogte: 79 mm; NLRS_C_lengte: 1200 mm; NLRS_P_c01_diameter: 40 mm; Volume: 0.00365971 m3; Z1: 91 mm
Identity Data - Design Option: Main Model; Mark: 1274; NLRS_C_code_product: EDMTAF 1200; NLRS_C_omschrijving: Multi TAF
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Family: NLRS_PF_52_UN_Multi TAF uitloop_Easydrain: Multi TAF horizontal outlet low 40mm; Family and Type: NLRS_PF_52_UN_Multi TAF uitloop_Easydrain: Multi TAF horizontal outlet low 40mm; Outlet Angle: 90 deg; product_index: 8; Ref line angle: 90 deg; Type: NLRS_PF_52_UN_Multi TAF uitloop_Easydrain: Multi TAF horizontal outlet low 40mm; Type Id: NLRS_PF_52_UN_Multi TAF uitloop_Easydrain: Multi TAF horizontal outlet low 40mm; Wall Profile: no; Build_in_depth_calculated: 79 mm; Discharge Center: 600 mm; Draingoot Depth: 20 mm; ExtensionSet_length: 17.5 mm; Flange width: 146 mm; H_Siphon: 54 mm; Leg length: 59 mm; Length calculated: 1165 mm; max_length: 2000 mm; offset_siphon: -27 mm; Outlet Depth: 34 mm; s: 2 mm; Siphon Height: 54 mm; Siphon position: 500 mm; Tile thickness calculated: 7 mm; Waterseal: 30 mm
Phasing - Phase Created: New Construction

# IfcFlowTerminal: Multi TAF zijuitloop hoog 50mm, zij-ingang 40mm, NLRS_PF_52_UN_Multi TAF in_uitloop_Easydrain:Multi TAF zijuitloop hoog 50mm, zij-ingang 40mm:3058501
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Multi TAF; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Multi TAF zijuitloop hoog 50mm, zij-ingang 40mm; URL: https://www.easydrain.nl/douchegoten/multi-taf/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: NLRS_n1_Asfalt_bitumen
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Multi TAF in_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi TAF zijuitloop hoog 50mm, zij-ingang 40mm
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Tile: no; Zero: yes; Single Extension Set: no; Extension Set: no; Siphon Left: yes; Siphon Right: no; Build-in-Depth: 90 mm; Grate Length: 1200 mm; Host: Level : Level 1; Tile Thickness: 7 mm
Dimensions - Do1: 50 mm; Do2: 40 mm; E1: 54 mm; E2: 49 mm; NLRS_C_breedte: 94 mm; NLRS_C_hoogte: 90 mm; NLRS_C_lengte: 1200 mm; NLRS_P_c01_diameter: 50 mm; NLRS_P_c02_diameter: 40 mm; Volume: 0.00365579 m3; Z1: 91 mm
Identity Data - Design Option: Main Model; Mark: 1283; NLRS_C_code_product: EDMTAF 1200; NLRS_C_omschrijving: Multi TAF
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Outlet Angle: 90 deg; product_index: 8; Ref line angle: 90 deg; Wall Profile: no; Build_in_depth_calculated: 90 mm; Discharge Center: 600 mm; Draingoot Depth: 20 mm; ExtensionSet_length: 17.5 mm; Family: NLRS_PF_52_UN_Multi TAF in_uitloop_Easydrain: Multi TAF zijuitloop hoog 50mm, zij-ingang 40mm; Family and Type: NLRS_PF_52_UN_Multi TAF in_uitloop_Easydrain: Multi TAF zijuitloop hoog 50mm, zij-ingang 40mm; Flange width: 146 mm; H_Siphon: 90 mm; Inlet Depth: 41 mm; Inlet Length: 91 mm; Leg length: 70 mm; Length calculated: 1165 mm; max_length: 2000 mm; offset_siphon: -27 mm; Outlet Depth: 36 mm; s: 2 mm; Siphon Height: 90 mm; Siphon position: 500 mm; Tile thickness calculated: 7 mm; Type: NLRS_PF_52_UN_Multi TAF in_uitloop_Easydrain: Multi TAF zijuitloop hoog 50mm, zij-ingang 40mm; Type Id: NLRS_PF_52_UN_Multi TAF in_uitloop_Easydrain: Multi TAF zijuitloop hoog 50mm, zij-ingang 40mm; Waterseal: 50 mm
Phasing - Phase Created: New Construction

# IfcFlowTerminal: Multi TAF zijuitloop hoog 50mm, zij-ingang 40mm (3)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_n1_Asfalt_bitumen, NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Multi TAF; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Multi TAF zijuitloop hoog 50mm, zij-ingang 40mm; URL: https://www.easydrain.nl/douchegoten/multi-taf/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: NLRS_n1_Asfalt_bitumen
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Multi TAF in_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi TAF zijuitloop hoog 50mm, zij-ingang 40mm
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Tile: yes; Level: Level: Level 1; Zero: no; Single Extension Set: no; Extension Set: no; Siphon Left: yes; Siphon Right: no; Build-in-Depth: 90 mm; Grate Length: 1200 mm; Host: Level : Level 1; Tile Thickness: 7 mm
Dimensions - Do1: 50 mm; Do2: 40 mm; E1: 54 mm; E2: 49 mm; NLRS_C_breedte: 94 mm; NLRS_C_hoogte: 90 mm; NLRS_C_lengte: 1200 mm; NLRS_P_c01_diameter: 50 mm; NLRS_P_c02_diameter: 40 mm; Volume: 0.00366028 m3; Z1: 91 mm
Identity Data - NLRS_C_code_product: EDMTAF 1200; NLRS_C_omschrijving: Multi TAF
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Outlet Angle: 90 deg; product_index: 8; Ref line angle: 90 deg; Wall Profile: no; Family: NLRS_PF_52_UN_Multi TAF in_uitloop_Easydrain: Multi TAF zijuitloop hoog 50mm, zij-ingang 40mm; Family and Type: NLRS_PF_52_UN_Multi TAF in_uitloop_Easydrain: Multi TAF zijuitloop hoog 50mm, zij-ingang 40mm; Type: NLRS_PF_52_UN_Multi TAF in_uitloop_Easydrain: Multi TAF zijuitloop hoog 50mm, zij-ingang 40mm; Type Id: NLRS_PF_52_UN_Multi TAF in_uitloop_Easydrain: Multi TAF zijuitloop hoog 50mm, zij-ingang 40mm; Build_in_depth_calculated: 90 mm; Discharge Center: 600 mm; Draingoot Depth: 20 mm; ExtensionSet_length: 17.5 mm; Flange width: 146 mm; H_Siphon: 90 mm; Inlet Depth: 41 mm; Inlet Length: 91 mm; Leg length: 70 mm; Length calculated: 1165 mm; max_length: 2000 mm; offset_siphon: -27 mm; Outlet Depth: 36 mm; s: 2 mm; Siphon Height: 90 mm; Siphon position: 500 mm; Tile thickness calculated: 7 mm; Waterseal: 50 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Multi TAF in_uitloop_Easydrain:Multi TAF zijuitloop hoog 50mm, zij-ingang 40mm:...) | Mark | Design Option
3058588 | 1286
3072145 | 1907 | Main Model
3083976 | 2358 | Main Model

# IfcFlowTerminal: Multi Tile horizontal outlet low 40mm (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_n1_Asfalt_bitumen, NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Multi Tile; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Multi Tile horizontal outlet low 40mm; URL: https://www.easydrain.nl/douchegoten/multi/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: NLRS_n1_Asfalt_bitumen
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Multi Tile uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi Tile horizontal outlet low 40mm
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Build-in-Depth: 59 mm; Grate Length: 1000 mm; Host: Level : Level 1
Dimensions - Do1: 40 mm; E1: 20 mm; NLRS_C_breedte: 94 mm; NLRS_C_hoogte: 89 mm; NLRS_C_lengte: 1035 mm; NLRS_P_c01_diameter: 40 mm; Volume: 0.00282456 m3; Z1: 91 mm
Identity Data - NLRS_C_code_product: EDT 1000; NLRS_C_omschrijving: Multi Tile
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Outlet Angle: 90 deg; Ref line angle: 90 deg; product_index: 6; Build_in_depth_calculated: 89 mm; Discharge Center: 500 mm; Draingoot Depth: 10 mm; Family: NLRS_PF_52_UN_Multi Tile uitloop_Easydrain: Multi Tile horizontal outlet low 40mm; Family and Type: NLRS_PF_52_UN_Multi Tile uitloop_Easydrain: Multi Tile horizontal outlet low 40mm; H_Siphon: 54 mm; Leg length: 59 mm; Length calculated: 1000 mm; max_length: 2000 mm; offset_siphon: -30 mm; Outlet Depth: 39 mm; s: 2 mm; Siphon Height: 59 mm; Siphon position: 500 mm; Tile Thickness: 20 mm; Tile thickness calculated: 20 mm; Type: NLRS_PF_52_UN_Multi Tile uitloop_Easydrain: Multi Tile horizontal outlet low 40mm; Type Id: NLRS_PF_52_UN_Multi Tile uitloop_Easydrain: Multi Tile horizontal outlet low 40mm; Waterseal: 30 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Multi Tile uitloop_Easydrain:Multi Tile horizontal outlet low 40mm:...) | Mark
3070153 | 1890
3083947 | 2347 | Identity Data - Design Option: Main Model

# IfcFlowTerminal: Multi Tile zijuitloop hoog 50mm, zij-ingang 40mm (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_n1_Asfalt_bitumen
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Multi Tile; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Multi Tile zijuitloop hoog 50mm, zij-ingang 40mm; URL: https://www.easydrain.nl/douchegoten/multi/
Type - Materials and Finishes - NLRS_C_materiaal_01: NLRS_n1_Asfalt_bitumen; NLRS_C_materiaal: NLRS_n1_Asfalt_bitumen
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Multi Tile in_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi Tile zijuitloop hoog 50mm, zij-ingang 40mm
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Build-in-Depth: 90 mm; Grate Length: 1000 mm; Host: Level : Level 1
Dimensions - Do1: 50 mm; Do2: 40 mm; E1: 54 mm; E2: 49 mm; NLRS_C_breedte: 94 mm; NLRS_C_hoogte: 120 mm; NLRS_C_lengte: 1000 mm; NLRS_P_c01_diameter: 50 mm; NLRS_P_c02_diameter: 40 mm; Volume: 0.00278616 m3; Z1: 91 mm
Identity Data - NLRS_C_code_product: EDT 1000; NLRS_C_omschrijving: Multi Tile
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Outlet Angle: 90 deg; Ref line angle: 90 deg; product_index: 6; Build_in_depth_calculated: 120 mm; Discharge Center: 500 mm; Draingoot Depth: 10 mm; Family: NLRS_PF_52_UN_Multi Tile in_uitloop_Easydrain: Multi Tile zijuitloop hoog 50mm, zij-ingang 40mm; Family and Type: NLRS_PF_52_UN_Multi Tile in_uitloop_Easydrain: Multi Tile zijuitloop hoog 50mm, zij-ingang 40mm; H_Siphon: 90 mm; Inlet Depth: 41 mm; Inlet Length: 91 mm; Leg length: 90 mm; Length calculated: 1000 mm; max_length: 2000 mm; offset_siphon: -30 mm; Outlet Depth: 36 mm; s: 2 mm; Siphon Height: 90 mm; Siphon position: 500 mm; Tile Thickness: 20 mm; Tile thickness calculated: 20 mm; Type: NLRS_PF_52_UN_Multi Tile in_uitloop_Easydrain: Multi Tile zijuitloop hoog 50mm, zij-ingang 40mm; Type Id: NLRS_PF_52_UN_Multi Tile in_uitloop_Easydrain: Multi Tile zijuitloop hoog 50mm, zij-ingang 40mm; Waterseal: 50 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Multi Tile in_uitloop_Easydrain:Multi Tile zijuitloop hoog 50mm, zij-ingang 40mm:...) | Mark
3070325 | 1894
3083949 | 2349 | Identity Data - Design Option: Main Model

# IfcFlowTerminal: Multi Trapezium horizontal outlet low 40mm (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Multi Trapezium; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Multi Trapezium horizontal outlet low 40mm; URL: https://www.easydrain.nl/douchegoten/trapezium/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Multi Trapezium uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi Trapezium horizontal outlet low 40mm
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Build-in-Depth: 59 mm; Host: Level : Level 1; Trapezium 300mm: yes; Trapezium 700mm: no
Dimensions - Do1: 40 mm; E1: 20 mm; Grate Length: 300 mm; NLRS_C_breedte: 98 mm; NLRS_C_hoogte: 59 mm; NLRS_C_lengte: 300 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.00077783 m3; Z1: 91 mm
Identity Data - NLRS_C_code_product: EDM TRAP300; NLRS_C_omschrijving: Multi Trapezium
Mechanical - System Classification: Sanitary
Other - Outlet angle: 90 deg; Build_in_depth_calculated: 59 mm; Draingoot Depth: 20 mm; Family: NLRS_PF_52_UN_Multi Trapezium uitloop_Easydrain: Multi Trapezium horizontal outlet low 40mm; Family and Type: NLRS_PF_52_UN_Multi Trapezium uitloop_Easydrain: Multi Trapezium horizontal outlet low 40mm; H_Siphon: 54 mm; Outlet Depth: 39 mm; Ref line angle: -45 deg; Siphon Height: 59 mm; Type: NLRS_PF_52_UN_Multi Trapezium uitloop_Easydrain: Multi Trapezium horizontal outlet low 40mm; Type Id: NLRS_PF_52_UN_Multi Trapezium uitloop_Easydrain: Multi Trapezium horizontal outlet low 40mm; Waterseal: 30 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Multi Trapezium uitloop_Easydrain:Multi Trapezium horizontal outlet low 40mm:...) | Mark
3072795 | 1920
3083989 | 2371 | Identity Data - Design Option: Main Model

# IfcFlowTerminal: Multi Trapezium zijuitloop hoog 50mm, zij-ingang 40mm (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Multi Trapezium; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Multi Trapezium zijuitloop hoog 50mm, zij-ingang 40mm; URL: https://www.easydrain.nl/douchegoten/trapezium/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Multi Trapezium in_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi Trapezium zijuitloop hoog 50mm, zij-ingang 40mm
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Build-in-Depth: 59 mm; Host: Level : Level 1; Trapezium 300mm: no; Trapezium 700mm: yes
Dimensions - Do1: 50 mm; Do2: 40 mm; E1: 54 mm; E2: 49 mm; Grate Length: 700 mm; NLRS_C_breedte: 98 mm; NLRS_C_hoogte: 59 mm; NLRS_C_lengte: 700 mm; NLRS_P_c01_diameter: 50 mm; NLRS_P_c02_diameter: 40 mm; Volume: 0.00155223 m3; Z1: 91 mm
Identity Data - Design Option: Main Model; NLRS_C_code_product: EDM TRAP700; NLRS_C_omschrijving: Multi Trapezium
Mechanical - System Classification: Sanitary
Other - Outlet angle: 90 deg; Ref line angle: -45 deg; Build_in_depth_calculated: 59 mm; Draingoot Depth: 20 mm; Family: NLRS_PF_52_UN_Multi Trapezium in_uitloop_Easydrain: Multi Trapezium zijuitloop hoog 50mm, zij-ingang 40mm; Family and Type: NLRS_PF_52_UN_Multi Trapezium in_uitloop_Easydrain: Multi Trapezium zijuitloop hoog 50mm, zij-ingang 40mm; H_Siphon: 90 mm; Inlet Depth: 41 mm; Inlet Length: 91 mm; Outlet Depth: 36 mm; Siphon Height: 90 mm; Type: NLRS_PF_52_UN_Multi Trapezium in_uitloop_Easydrain: Multi Trapezium zijuitloop hoog 50mm, zij-ingang 40mm; Type Id: NLRS_PF_52_UN_Multi Trapezium in_uitloop_Easydrain: Multi Trapezium zijuitloop hoog 50mm, zij-ingang 40mm; Waterseal: 50 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Multi Trapezium in_uitloop_Easydrain:Multi Trapezium zijuitloop hoog 50mm, zij-ingang 40mm:...) | Mark
3072915 | 1922
3083991 | 2373

# IfcFlowTerminal: Multi horizontal outlet low 40mm (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_52_WPS_ EasyDrain, NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Multi; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Multi horizontal outlet low 40mm; URL: https://www.easydrain.nl/douchegoten/multi/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: NLRS_52_WPS_ EasyDrain
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Multi uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi horizontal outlet low 40mm
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Flange: no; Wall Profile: yes; Eccentric Right: no; Build-in-Depth: 59 mm; Eccentric Left: no; Grate Length: 800 mm; Grate Type: 3 - Outside; Host: Level : Level 1
Dimensions - Do1: 40 mm; E1: 20 mm; NLRS_C_breedte: 94 mm; NLRS_C_hoogte: 79 mm; NLRS_C_lengte: 835 mm; NLRS_P_c01_diameter: 40 mm; Volume: 0.000923606 m3; Z1: 91 mm
Identity Data - NLRS_C_code_product: EDMWI 800; NLRS_C_omschrijving: Multi Wall
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Outlet Angle: 90 deg; Ref line angle: 90 deg; Family: NLRS_PF_52_UN_Multi uitloop_Easydrain: Multi horizontal outlet low 40mm; Family and Type: NLRS_PF_52_UN_Multi uitloop_Easydrain: Multi horizontal outlet low 40mm; Type: NLRS_PF_52_UN_Multi uitloop_Easydrain: Multi horizontal outlet low 40mm; Type Id: NLRS_PF_52_UN_Multi uitloop_Easydrain: Multi horizontal outlet low 40mm; Build_in_depth_calculated: 79 mm; Discharge Center: 400 mm; Draingoot Depth: 5 mm; Flange Back: 66.5 mm; Flange front: 75 mm; Flange Length: 835 mm; H_Siphon: 54 mm; Leg length: 59 mm; Length calculated: 800 mm; max_length: 1200 mm; min_length: 800 mm; offset_siphon: -20 mm; Outlet Depth: 39 mm; product_index: 23; s: 2 mm; Siphon Height: 59 mm; Siphon position: 400 mm; Tile Thickness: 15 mm; Tile thickness calculated: 15 mm; Wall offset: 66 mm; Waterseal: 30 mm
Phasing - Phase Created: New Construction
Visibility - Flange_check: no; Wall check: yes
Name (NLRS_PF_52_UN_Multi uitloop_Easydrain:Multi horizontal outlet low 40mm:...) | Mark
3068590 | 1860
3083926 | 2326

# IfcFlowTerminal: Multi horizontal outlet low 40mm (4)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Multi; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Multi horizontal outlet low 40mm; URL: https://www.easydrain.nl/douchegoten/multi/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: NLRS_52_WPS_ EasyDrain
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Multi uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi horizontal outlet low 40mm
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Wall Profile: no; Build-in-Depth: 59 mm; Eccentric Right: no; Grate Length: 800 mm; Host: Level : Level 1
Dimensions - Do1: 40 mm; E1: 20 mm; NLRS_C_breedte: 94 mm; NLRS_C_hoogte: 79 mm; NLRS_C_lengte: 835 mm; NLRS_P_c01_diameter: 40 mm; Z1: 91 mm
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Outlet Angle: 90 deg; Ref line angle: 90 deg; Build_in_depth_calculated: 79 mm; Discharge Center: 400 mm; Draingoot Depth: 5 mm; Family: NLRS_PF_52_UN_Multi uitloop_Easydrain: Multi horizontal outlet low 40mm; Family and Type: NLRS_PF_52_UN_Multi uitloop_Easydrain: Multi horizontal outlet low 40mm; Flange Back: 66.5 mm; Flange front: 75 mm; Flange Length: 835 mm; H_Siphon: 54 mm; Leg length: 59 mm; Length calculated: 800 mm; offset_siphon: -20 mm; Outlet Depth: 39 mm; s: 2 mm; Siphon Height: 59 mm; Tile Thickness: 15 mm; Tile thickness calculated: 15 mm; Type: NLRS_PF_52_UN_Multi uitloop_Easydrain: Multi horizontal outlet low 40mm; Type Id: NLRS_PF_52_UN_Multi uitloop_Easydrain: Multi horizontal outlet low 40mm; Wall offset: 66 mm; Waterseal: 30 mm
Phasing - Phase Created: New Construction
Visibility - Wall check: no
Name (NLRS_PF_52_UN_Multi uitloop_Easydrain:Multi horizontal outlet low 40mm:...) | Flange = Flange_check | Eccentric Left | Grate Type | Volume (m3) | Mark | NLRS_C_code_product | NLRS_C_omschrijving | max_length (mm) | min_length (mm) | product_index | Siphon position (mm)
3067914 | no | yes | 2 - Excenter | 0.000431606 | 1857 | EDMIOS 800 | Multi Excentrisch | 900 | 600 | 21 | 67 | Identity Data - Design Option: Main Model
3068656 | yes | no | 4 - Move | 0.000667911 | 1863 | EDMIPR 800 | Multi Flens | 1200 | 500 | 14 | 400
3083923 | no | yes | 2 - Excenter | 0.000431606 | 2323 | EDMIOS 800 | Multi Excentrisch | 900 | 600 | 21 | 67 | Identity Data - Design Option: Main Model
3083929 | yes | no | 4 - Move | 0.000667911 | 2329 | EDMIPR 800 | Multi Flens | 1200 | 500 | 14 | 400

# IfcFlowTerminal: Multi horizontal outlet low 50mm (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Multi; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Multi horizontal outlet low 50mm; URL: https://www.easydrain.nl/douchegoten/multi/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: NLRS_52_WPS_ EasyDrain
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Multi uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi horizontal outlet low 50mm
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Flange: no; Wall Profile: no; Eccentric Right: no; Eccentric Left: no; Build-in-Depth: 59 mm; Grate Length: 800 mm; Grate Type: 1 - Fixt; Host: Level : Level 1
Dimensions - Do1: 50 mm; E1: 25 mm; NLRS_C_breedte: 94 mm; NLRS_C_hoogte: 79 mm; NLRS_C_lengte: 835 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.000431606 m3; Z1: 91 mm
Identity Data - NLRS_C_code_product: EDMI 800; NLRS_C_omschrijving: Multi
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - product_index: 5; Outlet Angle: 90 deg; Ref line angle: 90 deg; Build_in_depth_calculated: 79 mm; Discharge Center: 400 mm; Draingoot Depth: 5 mm; Family: NLRS_PF_52_UN_Multi uitloop_Easydrain: Multi horizontal outlet low 50mm; Family and Type: NLRS_PF_52_UN_Multi uitloop_Easydrain: Multi horizontal outlet low 50mm; Flange Back: 66.5 mm; Flange front: 75 mm; Flange Length: 835 mm; H_Siphon: 59 mm; Leg length: 59 mm; Length calculated: 800 mm; max_length: 1200 mm; min_length: 500 mm; offset_siphon: -20 mm; Outlet Depth: 34 mm; s: 2 mm; Siphon Height: 59 mm; Siphon position: 400 mm; Tile Thickness: 15 mm; Tile thickness calculated: 15 mm; Type: NLRS_PF_52_UN_Multi uitloop_Easydrain: Multi horizontal outlet low 50mm; Type Id: NLRS_PF_52_UN_Multi uitloop_Easydrain: Multi horizontal outlet low 50mm; Wall offset: 66 mm; Waterseal: 30 mm
Phasing - Phase Created: New Construction
Visibility - Flange_check: no; Wall check: no
Name (NLRS_PF_52_UN_Multi uitloop_Easydrain:Multi horizontal outlet low 50mm:...) | Mark
3068809 | 1869 | Identity Data - Design Option: Main Model
3083932 | 2332

# IfcFlowTerminal: Multi zijuitloop hoog 50mm, zij-ingang 40mm (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_52_WPS_ EasyDrain, NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Multi; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Multi zijuitloop hoog 50mm, zij-ingang 40mm; URL: https://www.easydrain.nl/douchegoten/multi/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: NLRS_52_WPS_ EasyDrain
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Multi in_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi zijuitloop hoog 50mm, zij-ingang 40mm
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Flange: no; Wall Profile: yes; Eccentric Right: no; Eccentric Left: no; Build-in-Depth: 59 mm; Grate Length: 800 mm; Grate Type: 8 - Tile; Host: Level : Level 1
Dimensions - Do1: 50 mm; Do2: 40 mm; E1: 54 mm; E2: 49 mm; NLRS_C_breedte: 94 mm; NLRS_C_hoogte: 79 mm; NLRS_C_lengte: 835 mm; NLRS_P_c01_diameter: 50 mm; NLRS_P_c02_diameter: 40 mm; Volume: 0.000923606 m3; Z1: 91 mm
Identity Data - NLRS_C_code_product: EDMWI 800; NLRS_C_omschrijving: Multi Wall
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Outlet Angle: 90 deg; Ref line angle: 90 deg; Family: NLRS_PF_52_UN_Multi in_uitloop_Easydrain: Multi zijuitloop hoog 50mm, zij-ingang 40mm; Family and Type: NLRS_PF_52_UN_Multi in_uitloop_Easydrain: Multi zijuitloop hoog 50mm, zij-ingang 40mm; Type: NLRS_PF_52_UN_Multi in_uitloop_Easydrain: Multi zijuitloop hoog 50mm, zij-ingang 40mm; Type Id: NLRS_PF_52_UN_Multi in_uitloop_Easydrain: Multi zijuitloop hoog 50mm, zij-ingang 40mm; Build_in_depth_calculated: 79 mm; Discharge Center: 400 mm; Draingoot Depth: 5 mm; Flange Back: 66.5 mm; Flange front: 75 mm; Flange Length: 835 mm; H_Siphon: 90 mm; Inlet Depth: 41 mm; Inlet Length: 91 mm; Leg length: 59 mm; Length calculated: 800 mm; max_length: 1200 mm; min_length: 800 mm; offset_siphon: -20 mm; Outlet Depth: 36 mm; product_index: 23; s: 2 mm; Siphon Height: 90 mm; Siphon position: 400 mm; Tile Thickness: 15 mm; Tile thickness calculated: 15 mm; Wall offset: 66 mm; Waterseal: 50 mm
Phasing - Phase Created: New Construction
Visibility - Flange_check: no; Wall check: yes
Name (NLRS_PF_52_UN_Multi in_uitloop_Easydrain:Multi zijuitloop hoog 50mm, zij-ingang 40mm:...) | Mark
3069633 | 1881
3083941 | 2341

# IfcFlowTerminal: Multi zijuitloop hoog 50mm, zij-ingang 40mm (6)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Multi; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Multi zijuitloop hoog 50mm, zij-ingang 40mm; URL: https://www.easydrain.nl/douchegoten/multi/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: NLRS_52_WPS_ EasyDrain
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Multi in_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi zijuitloop hoog 50mm, zij-ingang 40mm
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Wall Profile: no; Eccentric Left: no; Build-in-Depth: 59 mm; Grate Length: 800 mm; Host: Level : Level 1
Dimensions - Do1: 50 mm; Do2: 40 mm; E1: 54 mm; E2: 49 mm; NLRS_C_breedte: 94 mm; NLRS_C_hoogte: 79 mm; NLRS_C_lengte: 835 mm; NLRS_P_c01_diameter: 50 mm; NLRS_P_c02_diameter: 40 mm; Z1: 91 mm
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Outlet Angle: 90 deg; Ref line angle: 90 deg; Build_in_depth_calculated: 79 mm; Discharge Center: 400 mm; Draingoot Depth: 5 mm; Family: NLRS_PF_52_UN_Multi in_uitloop_Easydrain: Multi zijuitloop hoog 50mm, zij-ingang 40mm; Family and Type: NLRS_PF_52_UN_Multi in_uitloop_Easydrain: Multi zijuitloop hoog 50mm, zij-ingang 40mm; Flange Back: 66.5 mm; Flange front: 75 mm; Flange Length: 835 mm; H_Siphon: 90 mm; Inlet Depth: 41 mm; Inlet Length: 91 mm; Leg length: 59 mm; Length calculated: 800 mm; offset_siphon: -20 mm; Outlet Depth: 36 mm; s: 2 mm; Siphon Height: 90 mm; Tile Thickness: 15 mm; Tile thickness calculated: 15 mm; Type: NLRS_PF_52_UN_Multi in_uitloop_Easydrain: Multi zijuitloop hoog 50mm, zij-ingang 40mm; Type Id: NLRS_PF_52_UN_Multi in_uitloop_Easydrain: Multi zijuitloop hoog 50mm, zij-ingang 40mm; Wall offset: 66 mm; Waterseal: 50 mm
Phasing - Phase Created: New Construction
Visibility - Wall check: no
Name (NLRS_PF_52_UN_Multi in_uitloop_Easydrain:Multi zijuitloop hoog 50mm, zij-ingang 40mm:...) | Flange = Flange_check | Eccentric Right | Grate Type | Volume (m3) | Mark | NLRS_C_code_product | NLRS_C_omschrijving | product_index | max_length (mm) | min_length (mm) | Siphon position (mm)
3069433 | no | no | 6 - Zero | 0.000431606 | 1875 | EDMI 800 | Multi | 5 | 1200 | 500 | 400 | Identity Data - Design Option: Main Model
3069486 | no | yes | 7 - Carré | 0.000431606 | 1878 | EDMIOS 800 | Multi Excentrisch | 21 | 900 | 600 | 733
3069697 | yes | no | 1 - Fixt | 0.000667911 | 1884 | EDMIPR 800 | Multi Flens | 14 | 1200 | 500 | 400 | Identity Data - Design Option: Main Model
3083935 | no | no | 6 - Zero | 0.000431606 | 2335 | EDMI 800 | Multi | 5 | 1200 | 500 | 400 | Identity Data - Design Option: Main Model
3083938 | no | yes | 7 - Carré | 0.000431606 | 2338 | EDMIOS 800 | Multi Excentrisch | 21 | 900 | 600 | 733
3083944 | yes | no | 1 - Fixt | 0.000667911 | 2344 | EDMIPR 800 | Multi Flens | 14 | 1200 | 500 | 400

# IfcFlowTerminal: Round Flex Class (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Round Flex Class; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Round Flex Class; URL: https://www.easydrain.nl/douchegoten/round-flex-class/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Round Flex Class_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Round Flex Class
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Host: Level : Level 1
Dimensions - arc_length: 875 mm; Do: 50 mm; Grate Length: 875 mm; NLRS_C_breedte: 70 mm; NLRS_C_hoogte: 65 mm; NLRS_C_lengte: 875 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.00200812 m3
Identity Data - NLRS_C_code_product: EDFLCL ROUND; NLRS_C_omschrijving: Round Flex Class
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Build-in-Depth: 65 mm; Draingoot Width: 70 mm; Family: NLRS_PF_52_UN_Round Flex Class_Easydrain: Round Flex Class; Family and Type: NLRS_PF_52_UN_Round Flex Class_Easydrain: Round Flex Class; Leg Length: 65 mm; radius: 550 mm; radius2: 480 mm; Tile Thickness: 20 mm; Type: NLRS_PF_52_UN_Round Flex Class_Easydrain: Round Flex Class; Type Id: NLRS_PF_52_UN_Round Flex Class_Easydrain: Round Flex Class
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Round Flex Class_Easydrain:Round Flex Class:...) | Mark
3073934 | 1930 | Identity Data - Design Option: Main Model
3084023 | 2375

# IfcFlowTerminal: S-Line, NLRS_PF_52_UN_S-Line_Easydrain:S-Line:3086108
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: S-Line; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: S-Line; URL: http://www.easydrain.nl/douchegoten/s-line-douchegoot/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; m2_vertical: no; m2_flat: no; standard_siphon: yes; Siphon Connection: no; Family Name: NLRS_PF_52_UN_S-Line_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: S-Line
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Build-in_Depth: 90 mm; Grate Length: 750 mm; Host: Level : Level 1; Tile Thickness: 7 mm
Dimensions - Do: 50 mm; Do1: 50 mm; NLRS_C_breedte: 108 mm; NLRS_C_hoogte: 90 mm; NLRS_C_lengte: 700 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.00169715 m3
Identity Data - Mark: 2495; NLRS_C_code_product: S-Line 700; NLRS_C_omschrijving: S-Line
Mechanical - System Classification: Undefined
Other - Outlet Angle: 90 deg; horizontal: yes; ref_line_angle: 180 deg; Build-in-Depth_calculated: 90 mm; Draingoot_middle_Width: 108 mm; Draingoot Depth: 24.5 mm; Draingoot Height: 39 mm; Draingoot Width: 33 mm; Family: NLRS_PF_52_UN_S-Line_Easydrain: S-Line; Family and Type: NLRS_PF_52_UN_S-Line_Easydrain: S-Line; Flange Width: 134 mm; L_/_: 17.5 mm; Length_Calculated: 700 mm; max_length: 1200 mm; min_length: 700 mm; offset siphon: -7 mm; Outlet_depth: 70 mm; Outlet_pos_length: 25 mm; Outlet_pos_width: 25 mm; Outlet Length: 168 mm; Ro: 25 mm; Ro1: 25 mm; Siphon Depth: 63 mm; Siphon Width: 120 mm; Tile_Thickness_check: 7 mm; Tile_wall_Height: 8 mm; Tile_wall_thickness: 14 mm; Tile Length: 192 mm; Type: NLRS_PF_52_UN_S-Line_Easydrain: S-Line; Type Id: NLRS_PF_52_UN_S-Line_Easydrain: S-Line
Phasing - Phase Created: New Construction

# IfcFlowTerminal: S-Line, NLRS_PF_52_UN_Showerboard S-Line_Easydrain:S-Line:3373422
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: S-Line; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: S-Line; URL: https://www.easydrain.nl/betegelbare-douche-elementen/s-line-shower-board/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; m2_vertical: no; m2_flat: no; Family Name: NLRS_PF_52_UN_Showerboard S-Line_Easydrain; Max_width: 1100 mm; Siphon connection: no; Standard Siphon: yes
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: S-Line
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Host: Level : Level 1; Showerboard Length: 1200 mm; Showerboard Width: 1100 mm; Tile Thickness: 7 mm
Dimensions - Do: 50 mm; Do1: 50 mm; Draingoot Length: 660 mm; NLRS_C_breedte: 108 mm; NLRS_C_hoogte: 125 mm; NLRS_C_lengte: 695 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.0555813 m3
Identity Data - Mark: 2564; NLRS_C_code_product: SBS-LINE; NLRS_C_omschrijving: Shower Board S-line
Mechanical - System Classification: Sanitary
Other - horizontal: yes; ref_line_angle: 180 deg; Draingoot_middle_Width: 108 mm; Draingoot Depth: 24.5 mm; Draingoot Height: 39 mm; DraingootLength_calculated: 695 mm; Draingoot Width: 33 mm; Family: NLRS_PF_52_UN_Showerboard S-Line_Easydrain: S-Line; Family and Type: NLRS_PF_52_UN_Showerboard S-Line_Easydrain: S-Line; Flange Width: 134 mm; L_/_: 17.5 mm; Length check: 1200 mm; Max_length: 1200 mm; Min_length: 900 mm; Min_width: 850 mm; Offset outlet: 86 mm; Outlet_depth: 95 mm; Outlet_pos_length: 25 mm; Outlet_pos_width: 25 mm; Outlet Length: 168 mm; Ro: 25 mm; Ro1: 25 mm; Showerboard_thickness_end: 46 mm; Showerboard_thickness_wall: 36 mm; Siphon_angle: 90 deg; Siphon Depth: 79 mm; Siphon Length: 168 mm; Siphon Width: 120 mm; Tile_Thickness_check: 7 mm; Tile_wall_Height: 8 mm; Tile_wall_Thickness: 9.6 mm; Tile Length: 192 mm; Type: NLRS_PF_52_UN_Showerboard S-Line_Easydrain: S-Line; Type Id: NLRS_PF_52_UN_Showerboard S-Line_Easydrain: S-Line; Width check: 1100 mm
Phasing - Phase Created: New Construction

# IfcFlowTerminal: S-Line High, NLRS_PF_52_UN_S-Line TAF High_Easydrain:S-Line High:3086457
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: S-Line Heightened TAF; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: S-Line High; URL: http://www.easydrain.nl/douchegoten/s-line-douchegoot/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; m2_vertical: no; m2_flat: no; standard_siphon: yes; Siphon Connection: no; Family Name: NLRS_PF_52_UN_S-Line TAF High_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: S-Line High
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Build-in_Depth: 90 mm; Grate Length: 750 mm; Host: Level : Level 1; Tile Thickness: 17 mm
Dimensions - Do: 50 mm; Do1: 50 mm; NLRS_C_breedte: 108 mm; NLRS_C_hoogte: 90 mm; NLRS_C_lengte: 700 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.00165735 m3
Identity Data - Mark: 2500; NLRS_C_code_product: S-Line 700-HOOG; NLRS_C_omschrijving: S-Line TAF Verhoogd
Mechanical - System Classification: Undefined
Other - Outlet Angle: 90 deg; horizontal: yes; ref_line_angle: 180 deg; Build-in-Depth_calculated: 90 mm; Draingoot_middle_Width: 108 mm; Draingoot Depth: 24.5 mm; Draingoot Height: 39 mm; Draingoot Width: 33 mm; Family: NLRS_PF_52_UN_S-Line TAF High_Easydrain: S-Line High; Family and Type: NLRS_PF_52_UN_S-Line TAF High_Easydrain: S-Line High; Flange Width: 134 mm; L_/_: 17.5 mm; Length_Calculated: 700 mm; max_length: 1200 mm; min_length: 700 mm; offset siphon: -17 mm; Outlet_depth: 80 mm; Outlet_pos_length: 25 mm; Outlet_pos_width: 25 mm; Outlet Length: 168 mm; Ro: 25 mm; Ro1: 25 mm; Siphon Depth: 63 mm; Siphon Width: 120 mm; Tile_Thickness_check: 17 mm; Tile_wall_Height: 8 mm; Tile_wall_thickness: 14 mm; Tile Length: 192 mm; Type: NLRS_PF_52_UN_S-Line TAF High_Easydrain: S-Line High; Type Id: NLRS_PF_52_UN_S-Line TAF High_Easydrain: S-Line High
Phasing - Phase Created: New Construction

# IfcFlowTerminal: S-Line High met M2 ondiep sifonhuis, NLRS_PF_52_UN_S-Line TAF High_Easydrain:S-Line High met M2 ondiep sifonhuis:3086520
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: S-Line Heightened TAF; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: S-Line High met M2 ondiep sifonhuis; URL: http://www.easydrain.nl/douchegoten/s-line-douchegoot/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; m2_vertical: no; Siphon Connection: yes; m2_flat: yes; standard_siphon: no; Family Name: NLRS_PF_52_UN_S-Line TAF High_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: S-Line High met M2 ondiep sifonhuis
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Build-in_Depth: 90 mm; Grate Length: 750 mm; Host: Level : Level 1; Tile Thickness: 17 mm
Dimensions - Do: 40 mm; Do1: 50 mm; NLRS_C_breedte: 108 mm; NLRS_C_hoogte: 74.5 mm; NLRS_C_lengte: 700 mm; NLRS_P_c01_diameter: 40 mm; Volume: 0.00170483 m3
Identity Data - Mark: 2501; NLRS_C_code_product: S-Line 700-HOOG; NLRS_C_omschrijving: S-Line TAF Verhoogd
Mechanical - System Classification: Undefined
Other - Outlet Angle: 90 deg; horizontal: yes; ref_line_angle: 180 deg; Build-in-Depth_calculated: 74.5 mm; Draingoot_middle_Width: 108 mm; Draingoot Depth: 24.5 mm; Draingoot Height: 39 mm; Draingoot Width: 33 mm; Family: NLRS_PF_52_UN_S-Line TAF High_Easydrain: S-Line High met M2 ondiep sifonhuis; Family and Type: NLRS_PF_52_UN_S-Line TAF High_Easydrain: S-Line High met M2 ondiep sifonhuis; Flange Width: 134 mm; L_/_: 17.5 mm; Length_Calculated: 700 mm; max_length: 1200 mm; min_length: 700 mm; offset siphon: -17 mm; Outlet_depth: 44.5 mm; Outlet_pos_length: 25 mm; Outlet_pos_width: 25 mm; Outlet Length: 185 mm; Ro: 20 mm; Ro1: 25 mm; Siphon Depth: 63 mm; Siphon Width: 120 mm; Tile_Thickness_check: 17 mm; Tile_wall_Height: 8 mm; Tile_wall_thickness: 14 mm; Tile Length: 192 mm; Type: NLRS_PF_52_UN_S-Line TAF High_Easydrain: S-Line High met M2 ondiep sifonhuis; Type Id: NLRS_PF_52_UN_S-Line TAF High_Easydrain: S-Line High met M2 ondiep sifonhuis
Phasing - Phase Created: New Construction

# IfcFlowTerminal: S-Line High met M2 sifonhuis onderuitloop, NLRS_PF_52_UN_S-Line TAF High_Easydrain:S-Line High met M2 sifonhuis onderuitloop:3086606
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot verticale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: S-Line Heightened TAF; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: S-Line High met M2 sifonhuis onderuitloop; URL: http://www.easydrain.nl/douchegoten/s-line-douchegoot/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; m2_vertical: yes; m2_flat: no; Siphon Connection: yes; standard_siphon: no; Family Name: NLRS_PF_52_UN_S-Line TAF High_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: S-Line High met M2 sifonhuis onderuitloop
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Build-in_Depth: 90 mm; Grate Length: 750 mm; Host: Level : Level 1; Tile Thickness: 17 mm
Dimensions - Do: 50 mm; Do1: 50 mm; NLRS_C_breedte: 108 mm; NLRS_C_hoogte: 90 mm; NLRS_C_lengte: 700 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.00165735 m3
Identity Data - Design Option: Main Model; Mark: 2503; NLRS_C_code_product: S-Line 700-HOOG; NLRS_C_omschrijving: S-Line TAF Verhoogd
Mechanical - System Classification: Undefined
Other - horizontal: no; ref_line_angle: 180 deg; Outlet Angle: 180 deg; Build-in-Depth_calculated: 90 mm; Draingoot_middle_Width: 108 mm; Draingoot Depth: 24.5 mm; Draingoot Height: 39 mm; Draingoot Width: 33 mm; Family: NLRS_PF_52_UN_S-Line TAF High_Easydrain: S-Line High met M2 sifonhuis onderuitloop; Family and Type: NLRS_PF_52_UN_S-Line TAF High_Easydrain: S-Line High met M2 sifonhuis onderuitloop; Flange Width: 134 mm; L_/_: 17.5 mm; Length_Calculated: 700 mm; max_length: 1200 mm; min_length: 700 mm; offset siphon: -17 mm; Outlet_depth: 24.5 mm; Outlet_pos_length: 25 mm; Outlet_pos_width: 50 mm; Outlet Length: 213 mm; Ro: 25 mm; Ro1: 25 mm; Siphon Depth: 63 mm; Siphon Width: 120 mm; Tile_Thickness_check: 17 mm; Tile_wall_Height: 8 mm; Tile_wall_thickness: 14 mm; Tile Length: 192 mm; Type: NLRS_PF_52_UN_S-Line TAF High_Easydrain: S-Line High met M2 sifonhuis onderuitloop; Type Id: NLRS_PF_52_UN_S-Line TAF High_Easydrain: S-Line High met M2 sifonhuis onderuitloop
Phasing - Phase Created: New Construction

# IfcFlowTerminal: S-Line met M2 ondiep sifonhuis, NLRS_PF_52_UN_S-Line_Easydrain:S-Line met M2 ondiep sifonhuis:3086219
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: S-Line; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: S-Line met M2 ondiep sifonhuis; URL: http://www.easydrain.nl/douchegoten/s-line-douchegoot/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; m2_vertical: no; Siphon Connection: yes; m2_flat: yes; standard_siphon: no; Family Name: NLRS_PF_52_UN_S-Line_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: S-Line met M2 ondiep sifonhuis
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Build-in_Depth: 90 mm; Grate Length: 750 mm; Host: Level : Level 1; Tile Thickness: 7 mm
Dimensions - Do: 40 mm; Do1: 50 mm; NLRS_C_breedte: 108 mm; NLRS_C_hoogte: 74.5 mm; NLRS_C_lengte: 700 mm; NLRS_P_c01_diameter: 40 mm; Volume: 0.00174463 m3
Identity Data - Design Option: Main Model; Mark: 2496; NLRS_C_code_product: S-Line 700; NLRS_C_omschrijving: S-Line
Mechanical - System Classification: Undefined
Other - Outlet Angle: 90 deg; horizontal: yes; ref_line_angle: 180 deg; Build-in-Depth_calculated: 74.5 mm; Draingoot_middle_Width: 108 mm; Draingoot Depth: 24.5 mm; Draingoot Height: 39 mm; Draingoot Width: 33 mm; Family: NLRS_PF_52_UN_S-Line_Easydrain: S-Line met M2 ondiep sifonhuis; Family and Type: NLRS_PF_52_UN_S-Line_Easydrain: S-Line met M2 ondiep sifonhuis; Flange Width: 134 mm; L_/_: 17.5 mm; Length_Calculated: 700 mm; max_length: 1200 mm; min_length: 700 mm; offset siphon: -7 mm; Outlet_depth: 44.5 mm; Outlet_pos_length: 25 mm; Outlet_pos_width: 25 mm; Outlet Length: 185 mm; Ro: 20 mm; Ro1: 25 mm; Siphon Depth: 63 mm; Siphon Width: 120 mm; Tile_Thickness_check: 7 mm; Tile_wall_Height: 8 mm; Tile_wall_thickness: 14 mm; Tile Length: 192 mm; Type: NLRS_PF_52_UN_S-Line_Easydrain: S-Line met M2 ondiep sifonhuis; Type Id: NLRS_PF_52_UN_S-Line_Easydrain: S-Line met M2 ondiep sifonhuis
Phasing - Phase Created: New Construction

# IfcFlowTerminal: S-Line met M2 ondiep sifonhuis, NLRS_PF_52_UN_Showerboard S-Line_Easydrain:S-Line met M2 ondiep sifonhuis:3373584
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: S-Line; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: S-Line met M2 ondiep sifonhuis; URL: https://www.easydrain.nl/betegelbare-douche-elementen/s-line-shower-board/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; m2_vertical: no; m2_flat: yes; Family Name: NLRS_PF_52_UN_Showerboard S-Line_Easydrain; Max_width: 1100 mm; Siphon connection: yes; Standard Siphon: no
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: S-Line met M2 ondiep sifonhuis
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Host: Level : Level 1; Showerboard Length: 1200 mm; Showerboard Width: 1100 mm; Tile Thickness: 7 mm
Dimensions - Do: 40 mm; Do1: 50 mm; Draingoot Length: 660 mm; NLRS_C_breedte: 108 mm; NLRS_C_hoogte: 96 mm; NLRS_C_lengte: 695 mm; NLRS_P_c01_diameter: 40 mm; Volume: 0.0555813 m3
Identity Data - Mark: 2566; NLRS_C_code_product: SBS-LINE; NLRS_C_omschrijving: Shower Board S-line
Mechanical - System Classification: Sanitary
Other - horizontal: yes; ref_line_angle: 180 deg; Siphon_angle: 90 deg; Draingoot_middle_Width: 108 mm; Draingoot Depth: 24.5 mm; Draingoot Height: 39 mm; DraingootLength_calculated: 695 mm; Draingoot Width: 33 mm; Family: NLRS_PF_52_UN_Showerboard S-Line_Easydrain: S-Line met M2 ondiep sifonhuis; Family and Type: NLRS_PF_52_UN_Showerboard S-Line_Easydrain: S-Line met M2 ondiep sifonhuis; Flange Width: 134 mm; L_/_: 17.5 mm; Length check: 1200 mm; Max_length: 1200 mm; Min_length: 900 mm; Min_width: 850 mm; Offset outlet: 57 mm; Outlet_depth: 63 mm; Outlet_pos_length: 25 mm; Outlet_pos_width: 25 mm; Outlet Length: 185 mm; Ro: 20 mm; Ro1: 25 mm; Showerboard_thickness_end: 46 mm; Showerboard_thickness_wall: 36 mm; Siphon Depth: 50 mm; Siphon Length: 185 mm; Siphon Width: 120 mm; Tile_Thickness_check: 7 mm; Tile_wall_Height: 8 mm; Tile_wall_Thickness: 9.6 mm; Tile Length: 192 mm; Type: NLRS_PF_52_UN_Showerboard S-Line_Easydrain: S-Line met M2 ondiep sifonhuis; Type Id: NLRS_PF_52_UN_Showerboard S-Line_Easydrain: S-Line met M2 ondiep sifonhuis; Width check: 1100 mm
Phasing - Phase Created: New Construction

# IfcFlowTerminal: S-Line met M2 sifonhuis onderuitloop, NLRS_PF_52_UN_S-Line_Easydrain:S-Line met M2 sifonhuis onderuitloop:3086365
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot verticale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: S-Line; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: S-Line met M2 sifonhuis onderuitloop; URL: http://www.easydrain.nl/douchegoten/s-line-douchegoot/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; m2_vertical: yes; m2_flat: no; Siphon Connection: yes; standard_siphon: no; Family Name: NLRS_PF_52_UN_S-Line_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: S-Line met M2 sifonhuis onderuitloop
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Build-in_Depth: 90 mm; Grate Length: 750 mm; Host: Level : Level 1; Tile Thickness: 7 mm
Dimensions - Do: 50 mm; Do1: 50 mm; NLRS_C_breedte: 108 mm; NLRS_C_hoogte: 90 mm; NLRS_C_lengte: 700 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.00169715 m3
Identity Data - Mark: 2498; NLRS_C_code_product: S-Line 700; NLRS_C_omschrijving: S-Line
Mechanical - System Classification: Undefined
Other - horizontal: no; ref_line_angle: 180 deg; Outlet Angle: 180 deg; Build-in-Depth_calculated: 90 mm; Draingoot_middle_Width: 108 mm; Draingoot Depth: 24.5 mm; Draingoot Height: 39 mm; Draingoot Width: 33 mm; Family: NLRS_PF_52_UN_S-Line_Easydrain: S-Line met M2 sifonhuis onderuitloop; Family and Type: NLRS_PF_52_UN_S-Line_Easydrain: S-Line met M2 sifonhuis onderuitloop; Flange Width: 134 mm; L_/_: 17.5 mm; Length_Calculated: 700 mm; max_length: 1200 mm; min_length: 700 mm; offset siphon: -7 mm; Outlet_depth: 24.5 mm; Outlet_pos_length: 25 mm; Outlet_pos_width: 50 mm; Outlet Length: 213 mm; Ro: 25 mm; Ro1: 25 mm; Siphon Depth: 63 mm; Siphon Width: 120 mm; Tile_Thickness_check: 7 mm; Tile_wall_Height: 8 mm; Tile_wall_thickness: 14 mm; Tile Length: 192 mm; Type: NLRS_PF_52_UN_S-Line_Easydrain: S-Line met M2 sifonhuis onderuitloop; Type Id: NLRS_PF_52_UN_S-Line_Easydrain: S-Line met M2 sifonhuis onderuitloop
Phasing - Phase Created: New Construction

# IfcFlowTerminal: S-Line met M2 sifonhuis onderuitloop, NLRS_PF_52_UN_Showerboard S-Line_Easydrain:S-Line met M2 sifonhuis onderuitloop:3373674
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot verticale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: S-Line; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: S-Line met M2 sifonhuis onderuitloop; URL: https://www.easydrain.nl/betegelbare-douche-elementen/s-line-shower-board/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; m2_vertical: yes; m2_flat: no; Siphon connection: yes; Standard Siphon: no; Family Name: NLRS_PF_52_UN_Showerboard S-Line_Easydrain; Max_width: 1100 mm
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: S-Line met M2 sifonhuis onderuitloop
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Host: Level : Level 1; Showerboard Length: 1200 mm; Showerboard Width: 1100 mm; Tile Thickness: 7 mm
Dimensions - Do: 50 mm; Do1: 50 mm; Draingoot Length: 660 mm; NLRS_C_breedte: 108 mm; NLRS_C_hoogte: 259 mm; NLRS_C_lengte: 695 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.0555813 m3
Identity Data - Design Option: Main Model; Mark: 2568; NLRS_C_code_product: SBS-LINE; NLRS_C_omschrijving: Shower Board S-line
Mechanical - System Classification: Sanitary
