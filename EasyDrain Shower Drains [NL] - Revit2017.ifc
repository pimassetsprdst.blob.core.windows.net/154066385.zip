Properties of the parts of a building model (IFC2X3), part 1 of 2

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2017-08-18T16:21:47
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170419_0315(x64) - Exporter 17.0.1128.0 - Alternate UI 17.17.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Aug 18 16:21:47 2017 * Host: PC10-Erik * Database: C:\Users\ETENHA~1\AppData\Local\Temp\{256157B6-FE1D-4497-91F7-EAA77DCCB317}\ifc * Database version: 5507 * Database creation date: Fri Aug 18 16:21:35 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Aug 18 16:21:35 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Aug 18 16:21:35 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: Shower Drains NL; Phase: 18-08-2017

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 1 - Fixt (5)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_BuildingElementProxyCommon - Reference: 1 - Fixt
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain:1 - Fixt:...)
3068811
3069699
3083934
3083946
3153975

# IfcBuildingElementProxy: 2 - Excenter (2)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_BuildingElementProxyCommon - Reference: 2 - Excenter
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain:2 - Excenter:...)
3067916
3083925

# IfcBuildingElementProxy: 3 - Outside (2)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_BuildingElementProxyCommon - Reference: 3 - Outside
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain:3 - Outside:...)
3068592
3083928

# IfcBuildingElementProxy: 4 - Move (2)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_gepolijst
Pset_BuildingElementProxyCommon - Reference: 4 - Move
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain:4 - Move:...)
3068658
3083931

# IfcBuildingElementProxy: 6 - Zero (2)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_BuildingElementProxyCommon - Reference: 6 - Zero
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain:6 - Zero:...)
3069435
3083937

# IfcBuildingElementProxy: 7 - Carré (2)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_BuildingElementProxyCommon - Reference: 7 - Carré
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain:7 - Carré:...)
3069488
3083940

# IfcBuildingElementProxy: 8 - Tile (2)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_BuildingElementProxyCommon - Reference: 8 - Tile
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain:8 - Tile:...)
3069635
3083943

# IfcBuildingElementProxy: Aqua Brilliant met tegelbakje (2)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat); Material: Rubber, Silicone, NLRS_52_WPS_ EasyDrain
Pset_BuildingElementProxyCommon - Reference: Aqua Brilliant met tegelbakje
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_WPS Aqua Brilliant_Easydrain:Aqua Brilliant met tegelbakje:...)
3083708
4257443

# IfcBuildingElementProxy: Model Text:Model Text 1 (9)
In: Level 1
Pset_BuildingElementProxyCommon - Reference: Model Text 1

# IfcBuildingElementProxy: Model Text:Model Text 2 (61)
In: Level 1
Classification: 4A(74.10) standaard, algemeen (verzamelniveau) (Uniformat)
Pset_BuildingElementProxyCommon - Reference: Model Text 2

# IfcBuildingElementProxy: NLRS_PLF_52_UN_Easy Drain verlengset_Easydrain (36)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_BuildingElementProxyCommon - Reference: NLRS_PLF_52_UN_Easy Drain verlengset_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Extension Set_Easydrain:NLRS_PLF_52_UN_Easy Drain verlengset_Easydrain:...)
3054631
3054716
3055100
3055102
3055273
3055275
3055277
3055279
3063846
3063848
3063850
3063852
3063854
3063856
3063858
3063860
3083259
3083261
3083263
3083265
3083267
3083269
3083271
3083273
3083735
3083737
3083739
3083741
3083743
3083745
3083747
3083749
3084258
3084260
3084262
3084264

# IfcFlowTerminal: Aqua Brilliant onderuitloop 50mm, NLRS_PF_52_UN_Showerboard Aqua Brilliant_Easydrain:Aqua Brilliant onderuitloop 50mm:3373870
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, Rubber, Butyl
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Brilliant onderuitloop 50mm

# IfcFlowTerminal: Aqua Brilliant zijuitloop laag 50mm, NLRS_PF_52_UN_Showerboard Aqua Brilliant_Easydrain:Aqua Brilliant zijuitloop laag 50mm:3373740
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, Rubber, Butyl
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Brilliant zijuitloop laag 50mm

# IfcFlowTerminal: Aqua Delta / Delta Zero (6)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Delta / Delta Zero
Name (NLRS_PF_52_UN_Aqua Delta_Zero_Easydrain:Aqua Delta / Delta Zero:...)
3935236
3935247
3935284
3935285
3935294
3935295

# IfcFlowTerminal: Aqua Delta horizontal outlet high 50mm (3)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Delta horizontal outlet high 50mm
Name (NLRS_PF_52_UN_Aqua Delta_uitloop_Easydrain:Aqua Delta horizontal outlet high 50mm:...)
3062712
3065155
3083657

# IfcFlowTerminal: Aqua Delta horizontal outlet low 40mm (3)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Delta horizontal outlet low 40mm
Name (NLRS_PF_52_UN_Aqua Delta_uitloop_Easydrain:Aqua Delta horizontal outlet low 40mm:...)
3062478
3065151
3083653

# IfcFlowTerminal: Aqua Delta horizontal outlet low 50mm (3)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Delta horizontal outlet low 50mm
Name (NLRS_PF_52_UN_Aqua Delta_uitloop_Easydrain:Aqua Delta horizontal outlet low 50mm:...)
3062651
3065153
3083655

# IfcFlowTerminal: Aqua Delta onderuitloop 50mm, zij-ingang 40mm (3)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Delta onderuitloop 50mm, zij-ingang 40mm
Name (NLRS_PF_52_UN_Aqua Delta_in_uitloop_Easydrain:Aqua Delta onderuitloop 50mm, zij-ingang 40mm:...)
3062932
3065161
3083663

# IfcFlowTerminal: Aqua Delta onderuitloop 50mm, zij-ingang 50mm (3)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Delta onderuitloop 50mm, zij-ingang 50mm
Name (NLRS_PF_52_UN_Aqua Delta_in_uitloop_Easydrain:Aqua Delta onderuitloop 50mm, zij-ingang 50mm:...)
3063006
3065163
3083665

# IfcFlowTerminal: Aqua Delta vertical outlet 50mm (3)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Delta vertical outlet 50mm
Name (NLRS_PF_52_UN_Aqua Delta_uitloop_Easydrain:Aqua Delta vertical outlet 50mm:...)
3062782
3065157
3083659

# IfcFlowTerminal: Aqua Delta zijuitloop hoog 50mm, zij-ingang 40mm (3)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Delta zijuitloop hoog 50mm, zij-ingang 40mm
Name (NLRS_PF_52_UN_Aqua Delta_in_uitloop_Easydrain:Aqua Delta zijuitloop hoog 50mm, zij-ingang 40mm:...)
3062848
3065159
3083661

# IfcFlowTerminal: Aqua Jewels Delta horizontal outlet low 40mm (10)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Jewels Delta horizontal outlet low 40mm
Name (NLRS_PF_52_UN_Aqua Jewels Delta_uitloop_Easydrain:Aqua Jewels Delta horizontal outlet low 40mm:...)
3053820
3053902
3060218
3060220
3065031
3065033
3083533
3083535
3085762
3085832

# IfcFlowTerminal: Aqua Jewels Delta zijuitloop hoog 50mm, zij-ingang 40mm (10)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Jewels Delta zijuitloop hoog 50mm, zij-ingang 40mm
Name (NLRS_PF_52_UN_Aqua Jewels Delta_in_uitloop_Easydrain:Aqua Jewels Delta zijuitloop hoog 50mm, zij-ingang 40mm:...)
3054430
3054482
3060222
3060224
3065035
3065037
3083537
3083539
3085920
3086018

# IfcFlowTerminal: Aqua Plus Delta horizontal outlet high 50mm (12)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Plus Delta horizontal outlet high 50mm
Name (NLRS_PF_52_UN_Aqua Plus Delta_uitloop_Easydrain:Aqua Plus Delta horizontal outlet high 50mm:...)
3060430
3060498
3060568
3065043
3065051
3065059
3083545
3083553
3083561
3084114
3084122
3084130

# IfcFlowTerminal: Aqua Plus Delta horizontal outlet low 40mm (12)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Plus Delta horizontal outlet low 40mm
Name (NLRS_PF_52_UN_Aqua Plus Delta_uitloop_Easydrain:Aqua Plus Delta horizontal outlet low 40mm:...)
3060246
3060494
3060564
3065039
3065047
3065055
3083541
3083549
3083557
3084110
3084118
3084126

# IfcFlowTerminal: Aqua Plus Delta horizontal outlet low 50mm (12)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Plus Delta horizontal outlet low 50mm
Name (NLRS_PF_52_UN_Aqua Plus Delta_uitloop_Easydrain:Aqua Plus Delta horizontal outlet low 50mm:...)
3060412
3060496
3060566
3065041
3065049
3065057
3083543
3083551
3083559
3084112
3084120
3084128

# IfcFlowTerminal: Aqua Plus Delta onderuitloop 50mm, zij-ingang 40mm (12)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Plus Delta onderuitloop 50mm, zij-ingang 40mm
Name (NLRS_PF_52_UN_Aqua Plus Delta_in_uitloop_Easydrain:Aqua Plus Delta onderuitloop 50mm, zij-ingang 40mm:...)
3060624
3060632
3060640
3065065
3065071
3065077
3083567
3083573
3083579
3084136
3084142
3084148

# IfcFlowTerminal: Aqua Plus Delta onderuitloop 50mm, zij-ingang 50mm (12)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Plus Delta onderuitloop 50mm, zij-ingang 50mm
Name (NLRS_PF_52_UN_Aqua Plus Delta_in_uitloop_Easydrain:Aqua Plus Delta onderuitloop 50mm, zij-ingang 50mm:...)
3060626
3060634
3060642
3065067
3065073
3065079
3083569
3083575
3083581
3084138
3084144
3084150

# IfcFlowTerminal: Aqua Plus Delta vertical outlet 50mm (12)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Plus Delta vertical outlet 50mm
Name (NLRS_PF_52_UN_Aqua Plus Delta_uitloop_Easydrain:Aqua Plus Delta vertical outlet 50mm:...)
3060448
3060500
3060570
3065045
3065053
3065061
3083547
3083555
3083563
3084116
3084124
3084132

# IfcFlowTerminal: Aqua Plus Delta zijuitloop hoog 50mm, zij-ingang 40mm (12)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Plus Delta zijuitloop hoog 50mm, zij-ingang 40mm
Name (NLRS_PF_52_UN_Aqua Plus Delta_in_uitloop_Easydrain:Aqua Plus Delta zijuitloop hoog 50mm, zij-ingang 40mm:...)
3060622
3060630
3060638
3065063
3065069
3065075
3083565
3083571
3083577
3084134
3084140
3084146

# IfcFlowTerminal: Aqua Plus Quattro Horizontal Outlet Low 40mm (3)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat)
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Plus Quattro Horizontal Outlet Low 40mm
Name (NLRS_PF_52_UN_Aqua Plus Quattro_uitloop_Easydrain:Aqua Plus Quattro Horizontal Outlet Low 40mm:...)
3060668
3065081
3083583

# IfcFlowTerminal: Aqua Plus Quattro Horizontal outlet Low 50mm (3)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat)
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Plus Quattro Horizontal outlet Low 50mm
Name (NLRS_PF_52_UN_Aqua Plus Quattro_uitloop_Easydrain:Aqua Plus Quattro Horizontal outlet Low 50mm:...)
3060850
3065083
3083585

# IfcFlowTerminal: Aqua Plus Quattro Horizontal outlet high 50mm (3)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat)
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Plus Quattro Horizontal outlet high 50mm
Name (NLRS_PF_52_UN_Aqua Plus Quattro_uitloop_Easydrain:Aqua Plus Quattro Horizontal outlet high 50mm:...)
3061043
3065085
3083587

# IfcFlowTerminal: Aqua Plus Quattro Vertical Outlet 50mm (3)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat)
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Plus Quattro Vertical Outlet 50mm
Name (NLRS_PF_52_UN_Aqua Plus Quattro_uitloop_Easydrain:Aqua Plus Quattro Vertical Outlet 50mm:...)
3061100
3065087
3083589

# IfcFlowTerminal: Aqua Plus Quattro onderuitloop 50mm, zij-ingang 40mm (3)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat)
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Plus Quattro onderuitloop 50mm, zij-ingang 40mm
Name (NLRS_PF_52_UN_Aqua Plus Quattro_in_uitloop_Easydrain:Aqua Plus Quattro onderuitloop 50mm, zij-ingang 40mm:...)
3061261
3065091
3083593

# IfcFlowTerminal: Aqua Plus Quattro onderuitloop 50mm, zij-ingang 50mm (3)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat)
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Plus Quattro onderuitloop 50mm, zij-ingang 50mm
Name (NLRS_PF_52_UN_Aqua Plus Quattro_in_uitloop_Easydrain:Aqua Plus Quattro onderuitloop 50mm, zij-ingang 50mm:...)
3061367
3065093
3083595

# IfcFlowTerminal: Aqua Plus Quattro zijuitloop hoog 50mm, zij-ingang 40mm (3)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat)
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Plus Quattro zijuitloop hoog 50mm, zij-ingang 40mm
Name (NLRS_PF_52_UN_Aqua Plus Quattro_in_uitloop_Easydrain:Aqua Plus Quattro zijuitloop hoog 50mm, zij-ingang 40mm:...)
3061181
3065089
3083591

# IfcFlowTerminal: Aqua Quattro Horizontal Outlet Low 40mm (6)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat)
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Quattro Horizontal Outlet Low 40mm
Name (NLRS_PF_52_UN_Aqua Quattro_uitloop_Easydrain:Aqua Quattro Horizontal Outlet Low 40mm:...)
3061519
3061591
3065095
3065109
3083597
3083611

# IfcFlowTerminal: Aqua Quattro Horizontal outlet Low 50mm (6)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat)
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Quattro Horizontal outlet Low 50mm
Name (NLRS_PF_52_UN_Aqua Quattro_uitloop_Easydrain:Aqua Quattro Horizontal outlet Low 50mm:...)
3061521
3061593
3065097
3065111
3083599
3083613

# IfcFlowTerminal: Aqua Quattro Horizontal outlet high 50mm (6)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat)
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Quattro Horizontal outlet high 50mm
Name (NLRS_PF_52_UN_Aqua Quattro_uitloop_Easydrain:Aqua Quattro Horizontal outlet high 50mm:...)
3061523
3061595
3065099
3065113
3083601
3083615

# IfcFlowTerminal: Aqua Quattro Vertical Outlet 50mm (6)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat)
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Quattro Vertical Outlet 50mm
Name (NLRS_PF_52_UN_Aqua Quattro_uitloop_Easydrain:Aqua Quattro Vertical Outlet 50mm:...)
3061525
3061597
3065101
3065115
3083603
3083617

# IfcFlowTerminal: Aqua Quattro onderuitloop 50mm, zij-ingang 40mm (6)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat)
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Quattro onderuitloop 50mm, zij-ingang 40mm
Name (NLRS_PF_52_UN_Aqua Quattro_in_uitloop_Easydrain:Aqua Quattro onderuitloop 50mm, zij-ingang 40mm:...)
3061529
3061601
3065105
3065119
3083607
3083621

# IfcFlowTerminal: Aqua Quattro zijuitloop hoog 50mm, zij-ingang 40mm (12)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat)
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Quattro zijuitloop hoog 50mm, zij-ingang 40mm
Name (NLRS_PF_52_UN_Aqua Quattro_in_uitloop_Easydrain:Aqua Quattro zijuitloop hoog 50mm, zij-ingang 40mm:...)
3061527
3061531
3061599
3061603
3065103
3065107
3065117
3065121
3083605
3083609
3083619
3083623

# IfcFlowTerminal: Aqua Round Horizontal Outlet Low 40mm (6)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Round Horizontal Outlet Low 40mm
Name (NLRS_PF_52_UN_Aqua Round_uitloop_Easydrain:Aqua Round Horizontal Outlet Low 40mm:...)
3061633
3062431
3065123
3065137
3083625
3083639

# IfcFlowTerminal: Aqua Round Horizontal outlet Low 50mm (6)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Round Horizontal outlet Low 50mm
Name (NLRS_PF_52_UN_Aqua Round_uitloop_Easydrain:Aqua Round Horizontal outlet Low 50mm:...)
3061927
3062433
3065125
3065139
3083627
3083641

# IfcFlowTerminal: Aqua Round Horizontal outlet high 50mm (6)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Round Horizontal outlet high 50mm
Name (NLRS_PF_52_UN_Aqua Round_uitloop_Easydrain:Aqua Round Horizontal outlet high 50mm:...)
3062002
3062435
3065127
3065141
3083629
3083643

# IfcFlowTerminal: Aqua Round Vertical Outlet 50mm (6)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Round Vertical Outlet 50mm
Name (NLRS_PF_52_UN_Aqua Round_uitloop_Easydrain:Aqua Round Vertical Outlet 50mm:...)
3062069
3062437
3065129
3065143
3083631
3083645

# IfcFlowTerminal: Aqua Round onderuitloop 50mm, zij-ingang 40mm (6)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Round onderuitloop 50mm, zij-ingang 40mm
Name (NLRS_PF_52_UN_Aqua Round_in_uitloop_Easydrain:Aqua Round onderuitloop 50mm, zij-ingang 40mm:...)
3062379
3062443
3065135
3065149
3083637
3083651

# IfcFlowTerminal: Aqua Round onderuitloop 50mm, zij-ingang 50mm (6)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Round onderuitloop 50mm, zij-ingang 50mm
Name (NLRS_PF_52_UN_Aqua Round_in_uitloop_Easydrain:Aqua Round onderuitloop 50mm, zij-ingang 50mm:...)
3062251
3062441
3065133
3065147
3083635
3083649

# IfcFlowTerminal: Aqua Round zijuitloop hoog 50mm, zij-ingang 40mm (6)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Round zijuitloop hoog 50mm, zij-ingang 40mm
Name (NLRS_PF_52_UN_Aqua Round_in_uitloop_Easydrain:Aqua Round zijuitloop hoog 50mm, zij-ingang 40mm:...)
3062151
3062439
3065131
3065145
3083633
3083647

# IfcFlowTerminal: Black Glass 10x10 (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_52_WPS_ EasyDrain, NLRS_o_Glas_zwart, Roestvrijstaal,geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Black Glass 10x10
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain:Black Glass 10x10:...)
3053128
3053453
3060101
3060146
3064961
3065006
3083463
3083508

# IfcFlowTerminal: Black Glass 15x15 (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_52_WPS_ EasyDrain, NLRS_o_Glas_zwart, Roestvrijstaal,geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Black Glass 15x15
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain:Black Glass 15x15:...)
3053131
3053456
3060104
3060149
3064964
3065009
3083466
3083511

# IfcFlowTerminal: Black Glass 20x20 (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_52_WPS_ EasyDrain, NLRS_o_Glas_zwart, Roestvrijstaal,geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Black Glass 20x20
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain:Black Glass 20x20:...)
3053134
3053459
3060107
3060152
3064967
3065012
3083469
3083514

# IfcFlowTerminal: Brilliant onderuitloop 50mm (4)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, Rubber, Butyl
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Brilliant onderuitloop 50mm
Name (NLRS_PF_52_UN_Aqua Brilliant_Easydrain:Brilliant onderuitloop 50mm:...)
3063278
3065166
3083216
3083668

# IfcFlowTerminal: Brilliant zijuitloop laag 50mm (4)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, Rubber, Butyl
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Brilliant zijuitloop laag 50mm
Name (NLRS_PF_52_UN_Aqua Brilliant_Easydrain:Brilliant zijuitloop laag 50mm:...)
3063088
3065165
3083215
3083667

# IfcFlowTerminal: Compact (29)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact
Name
NLRS_PF_52_UN_Aqua Compact_Easydrain:Compact:3063368
NLRS_PF_52_UN_Aqua Compact_Easydrain:Compact:3063654
NLRS_PF_52_UN_Aqua Compact_Easydrain:Compact:3063690
NLRS_PF_52_UN_Aqua Compact_Easydrain:Compact:3063691
NLRS_PF_52_UN_Aqua Compact_Easydrain:Compact:3065167
NLRS_PF_52_UN_Aqua Compact_Easydrain:Compact:3065168
NLRS_PF_52_UN_Aqua Compact_Easydrain:Compact:3065169
NLRS_PF_52_UN_Aqua Compact_Easydrain:Compact:3065170
NLRS_PF_52_UN_Aqua Compact_Easydrain:Compact:3083217
NLRS_PF_52_UN_Aqua Compact_Easydrain:Compact:3083218
NLRS_PF_52_UN_Aqua Compact_Easydrain:Compact:3083219
NLRS_PF_52_UN_Aqua Compact_Easydrain:Compact:3083220
NLRS_PF_52_UN_Compact_Easydrain:Compact:3083349
NLRS_PF_52_UN_Compact_Easydrain:Compact:3083350
NLRS_PF_52_UN_Compact_Easydrain:Compact:3083351
NLRS_PF_52_UN_Compact_Easydrain:Compact:3083352
NLRS_PF_52_UN_Aqua Compact_Easydrain:Compact:3083669
NLRS_PF_52_UN_Aqua Compact_Easydrain:Compact:3083670
NLRS_PF_52_UN_Aqua Compact_Easydrain:Compact:3083671
NLRS_PF_52_UN_Aqua Compact_Easydrain:Compact:3083672
NLRS_PF_52_UN_Showerboard Compact_Easydrain:Compact:3373956
NLRS_PF_52_UN_Compact_Easydrain:Compact:3961698
NLRS_PF_52_UN_Compact_Easydrain:Compact:3961699
NLRS_PF_52_UN_Compact_Easydrain:Compact:3961700
NLRS_PF_52_UN_Compact_Easydrain:Compact:3961701
NLRS_PF_52_UN_Compact_Easydrain:Compact:3961733
NLRS_PF_52_UN_Compact_Easydrain:Compact:3961734
NLRS_PF_52_UN_Compact_Easydrain:Compact:3961735
NLRS_PF_52_UN_Compact_Easydrain:Compact:3961736

# IfcFlowTerminal: Compact FF (16)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact FF
Name (NLRS_PF_52_UN_Compact_Easydrain:Compact FF:...)
3057215
3057258
3057371
3057422
3066581
3066582
3067597
3067598
3083410
3083411
3083412
3083413
3083816
3083817
3083822
3083823

# IfcFlowTerminal: Compact FF Tile (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_n1_Asfalt_bitumen, NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact FF Tile
Name (NLRS_PF_52_UN_Compact Tile_Easydrain:Compact FF Tile:...)
3057881
3057998
3067716
3067757
3083414
3083415
3083824
3083825

# IfcFlowTerminal: Compact Flange (6)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact Flange
Name (NLRS_PF_52_UN_Compact_Easydrain:Compact Flange:...)
3083353
3083355
3961702
3961703
3961737
3961738

# IfcFlowTerminal: Compact M2, NLRS_PF_52_UN_Showerboard Compact M2_Easydrain:Compact M2:3374100
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact M2

# IfcFlowTerminal: Compact M2 met M2 ondiep sifonhuis, NLRS_PF_52_UN_Showerboard Compact M2_Easydrain:Compact M2 met M2 ondiep sifonhuis:3374188
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact M2 met M2 ondiep sifonhuis

# IfcFlowTerminal: Compact M2 met M2 sifonhuis onderuitloop, NLRS_PF_52_UN_Showerboard Compact M2_Easydrain:Compact M2 met M2 sifonhuis onderuitloop:3374267
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact M2 met M2 sifonhuis onderuitloop

# IfcFlowTerminal: Compact Modulo Stone (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_e_natuursteen, NLRS_52_WPS_ EasyDrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact Modulo Stone
Name (NLRS_PF_52_UN_Compact Modulo Stone_Easydrain:Compact Modulo Stone:...)
3376299
3376407

# IfcFlowTerminal: Compact TAF (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact TAF
Name (NLRS_PF_52_UN_Compact TAF_Easydrain:Compact TAF:...)
3054630
3055099
3063845
3063849
3083258
3083262
3083734
3083738

# IfcFlowTerminal: Compact TAF (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_n1_Asfalt_bitumen, NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact TAF
Name (NLRS_PF_52_UN_Compact TAF_Easydrain:Compact TAF:...)
3054715
3055101
3063847
3063851
3083260
3083264
3083736
3083740

# IfcFlowTerminal: Compact TAF Low Inleg (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_n1_Asfalt_bitumen, NLRS_52_WPS_ EasyDrain, Default
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact TAF Low Inleg
Name (NLRS_PF_52_UN_Compact TAF Low_Easydrain:Compact TAF Low Inleg:...)
3063922
3064200

# IfcFlowTerminal: Compact TAF Low Zero geborsteld RVS (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain, Default
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact TAF Low Zero geborsteld RVS
Name (NLRS_PF_52_UN_Compact TAF Low_Easydrain:Compact TAF Low Zero geborsteld RVS:...)
3064282
3064366

# IfcFlowTerminal: Compact TAF Modulo Classic (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact TAF Modulo Classic
Name (NLRS_PF_52_UN_Compact TAF Modulo_Easydrain:Compact TAF Modulo Classic:...)
3055458
3056412
3063861
3063871
3083297
3083307
3083750
3083760

# IfcFlowTerminal: Compact TAF Modulo Design Z2 (6)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact TAF Modulo Design Z2
Name (NLRS_PF_52_UN_Compact TAF Modulo Design_Easydrain:Compact TAF Modulo Design Z2:...)
3056470
3056667
3063881
3063883
3083770
3083772

# IfcFlowTerminal: Compact TAF Modulo Design Z4 (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact TAF Modulo Design Z4
Name (NLRS_PF_52_UN_Compact TAF Modulo Design_Easydrain:Compact TAF Modulo Design Z4:...)
3056586
3056668
3063882
3063884
3083771
3083773
3084323
3084465

# IfcFlowTerminal: Compact TAF Modulo Glas wit glans (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: Glass, Cast, White, NLRS_52_WPS_ EasyDrain, NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact TAF Modulo Glas wit glans
Name (NLRS_PF_52_UN_Compact TAF Modulo_Easydrain:Compact TAF Modulo Glas wit glans:...)
3055766
3056414
3063863
3063873
3083299
3083309
3083752
3083762

# IfcFlowTerminal: Compact TAF Modulo Glas zwart glans (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: Glass, Cast, Gray, NLRS_52_WPS_ EasyDrain, NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact TAF Modulo Glas zwart glans
Name (NLRS_PF_52_UN_Compact TAF Modulo_Easydrain:Compact TAF Modulo Glas zwart glans:...)
3055933
3056416
3063865
3063875
3083301
3083311
3083754
3083764

# IfcFlowTerminal: Compact TAF Modulo Zero+ geborsteld RVS (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact TAF Modulo Zero+ geborsteld RVS
Name (NLRS_PF_52_UN_Compact TAF Modulo_Easydrain:Compact TAF Modulo Zero+ geborsteld RVS:...)
3056106
3056418
3063867
3063877
3083303
3083313
3083756
3083766

# IfcFlowTerminal: Compact TAF Modulo Zero+ verchroomd RVS (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_gepolijst, NLRS_52_WPS_ EasyDrain, NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact TAF Modulo Zero+ verchroomd RVS
Name (NLRS_PF_52_UN_Compact TAF Modulo_Easydrain:Compact TAF Modulo Zero+ verchroomd RVS:...)
3056276
3056420
3063869
3063879
3083305
3083315
3083758
3083768

# IfcFlowTerminal: Compact TAF Wall (10)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact TAF Wall
Name (NLRS_PF_52_UN_Compact TAF_Easydrain:Compact TAF Wall:...)
3055272
3055276
3063853
3063857
3083266
3083270
3083742
3083746
3084257
3084261

# IfcFlowTerminal: Compact TAF Wall (10)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_n1_Asfalt_bitumen, NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact TAF Wall
Name (NLRS_PF_52_UN_Compact TAF_Easydrain:Compact TAF Wall:...)
3055274
3055278
3063855
3063859
3083268
3083272
3083744
3083748
3084259
3084263

# IfcFlowTerminal: Compact Tile (6)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_n1_Asfalt_bitumen, NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact Tile
Name (NLRS_PF_52_UN_Compact Tile_Easydrain:Compact Tile:...)
3083357
3083358
3961704
3961705
3961739
3961740

# IfcFlowTerminal: Compact Wall (14)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact Wall
Name (NLRS_PF_52_UN_Compact_Easydrain:Compact Wall:...)
3083359
3083360
3083361
3083362
3085505
3085612
3961706
3961707
3961708
3961709
3961741
3961742
3961743
3961744

# IfcFlowTerminal: Dot Onderuitloop 50 mm, NLRS_PF_52_UN_Showerboard DOT_uitloop_Easydrain:Dot Onderuitloop 50 mm:3372371
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, Default
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Dot Onderuitloop 50 mm

# IfcFlowTerminal: Dot Zijuitloop hoog 50 mm, NLRS_PF_52_UN_Showerboard DOT_uitloop_Easydrain:Dot Zijuitloop hoog 50 mm:3372299
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, Default
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Dot Zijuitloop hoog 50 mm

# IfcFlowTerminal: Dot Zijuitloop laag 40 mm, NLRS_PF_52_UN_Showerboard DOT_uitloop_Easydrain:Dot Zijuitloop laag 40 mm:3372089
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, Default
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Dot Zijuitloop laag 40 mm

# IfcFlowTerminal: Dot Zijuitloop laag 50 mm, NLRS_PF_52_UN_Showerboard DOT_uitloop_Easydrain:Dot Zijuitloop laag 50 mm:3372222
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, Default
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Dot Zijuitloop laag 50 mm

# IfcFlowTerminal: Dot onderuitloop 50mm, zij-ingang 40mm, NLRS_PF_52_UN_Showerboard DOT_in_uitloop_Easydrain:Dot onderuitloop 50mm, zij-ingang 40mm:3372564
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, Default
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Dot onderuitloop 50mm, zij-ingang 40mm

# IfcFlowTerminal: Dot onderuitloop 50mm, zij-ingang 50mm, NLRS_PF_52_UN_Showerboard DOT_in_uitloop_Easydrain:Dot onderuitloop 50mm, zij-ingang 50mm:3372660
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, Default
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Dot onderuitloop 50mm, zij-ingang 50mm

# IfcFlowTerminal: Dot zijuitloop hoog 50mm, zij-ingang 40mm, NLRS_PF_52_UN_Showerboard DOT_in_uitloop_Easydrain:Dot zijuitloop hoog 50mm, zij-ingang 40mm:3372464
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, Default
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Dot zijuitloop hoog 50mm, zij-ingang 40mm

# IfcFlowTerminal: Green Glass 10x10 (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_52_WPS_ EasyDrain, NLRS_o_Glas_groen, Roestvrijstaal,geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Green Glass 10x10
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain:Green Glass 10x10:...)
3053162
3053471
3060119
3060164
3064979
3065024
3083481
3083526

# IfcFlowTerminal: Green Glass 15x15 (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_52_WPS_ EasyDrain, NLRS_o_Glas_groen, Roestvrijstaal,geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Green Glass 15x15
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain:Green Glass 15x15:...)
3053165
3053474
3060122
3060167
3064982
3065027
3083484
3083529

# IfcFlowTerminal: Green Glass 20x20 (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_52_WPS_ EasyDrain, NLRS_o_Glas_groen, Roestvrijstaal,geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Green Glass 20x20
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain:Green Glass 20x20:...)
3053168
3053477
3060125
3060170
3064985
3065030
3083487
3083532

# IfcFlowTerminal: M-Line (12)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, Default
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: M-Line
Name (NLRS_PF_52_UN_M-Line_Easydrain:M-Line:...)
3374400
3374480
3374618
3374652
3374818
3374819
3374820
3374821
3374886
3374894
3374904
3374926

# IfcFlowTerminal: M2 Flat Siphon (15)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat)
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: M2 Flat Siphon
Name
Z_DO_NOT_USE_NLRS_PF_52_UN_M2 Flat Siphon_Easydrain_XS NANO:M2 Flat Siphon:3074302
Z_DO_NOT_USE_NLRS_PF_52_UN_M2 Flat Siphon_Easydrain_XS NANO:M2 Flat Siphon:3074332
Z_DO_NOT_USE_NLRS_PF_52_UN_M2 Flat Siphon_Easydrain_XS NANO:M2 Flat Siphon:3078788
Z_DO_NOT_USE_NLRS_PF_52_UN_M2 Flat Siphon_Easydrain_XS NANO:M2 Flat Siphon:3078802
Z_DO_NOT_USE_NLRS_PF_52_UN_M2 Flat Siphon_Easydrain_XS NANO:M2 Flat Siphon:3083190
Z_DO_NOT_USE_NLRS_PF_52_UN_M2 Flat Siphon_Easydrain_XS NANO:M2 Flat Siphon:3083204
Z_DO_NOT_USE_NLRS_PF_52_UN_M2 Flat Siphon_Easydrain_XS NANO:M2 Flat Siphon:3084030
Z_DO_NOT_USE_NLRS_PF_52_UN_M2 Flat Siphon_Easydrain_XS NANO:M2 Flat Siphon:3084035
Z_DO_NOT_USE_NLRS_PF_52_UN_M2 Flat Siphon_Easydrain_XS NANO:M2 Flat Siphon:3084044
Z_DO_NOT_USE_NLRS_PF_52_UN_M2 Flat Siphon_Easydrain_XS NANO:M2 Flat Siphon:3084046
Z_DO_NOT_USE_NLRS_PF_52_UN_M2 Flat Siphon_Easydrain_XS NANO:M2 Flat Siphon:3084054
Z_DO_NOT_USE_NLRS_PF_52_UN_M2 Flat Siphon_Easydrain_XS NANO:M2 Flat Siphon:3084056
Z_DO_NOT_USE_NLRS_PF_52_UN_M2 Flat Siphon_Easydrain_S-Line Waterstop:M2 Flat Siphon:3373585
Z_DO_NOT_USE_NLRS_PF_52_UN_M2 Flat Siphon_Easydrain_S-Line Waterstop:M2 Flat Siphon:3374189
Z_DO_NOT_USE_NLRS_PF_52_UN_M2 Flat Siphon_Easydrain_XS NANO:M2 Flat Siphon:3962057

# IfcFlowTerminal: M2 Trap Body (18)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat)
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: M2 Trap Body
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_M2 Vertical Outlet_Easydrain:M2 Trap Body:...)
3064867
3074312
3074342
3078793
3078807
3083195
3083209
3084032
3084037
3084045
3084047
3084055
3084057
3086366
3086607
3373675
3374268
3962059

# IfcFlowTerminal: M2 ondiep sifonhuis (2)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat)
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: M2 ondiep sifonhuis
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_M2 Flat Siphon_Easydrain_S-Line:M2 ondiep sifonhuis:...)
3086220
3086521

# IfcFlowTerminal: Multi Long Length horizontal outlet low 40mm (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi Long Length horizontal outlet low 40mm
Name (NLRS_PF_52_UN_Multi Long Length uitloop_Easydrain:Multi Long Length horizontal outlet low 40mm:...)
3070456
3083951

# IfcFlowTerminal: Multi Long Length zijuitloop hoog 50mm, zij-ingang 40mm (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi Long Length zijuitloop hoog 50mm, zij-ingang 40mm
Name (NLRS_PF_52_UN_Multi Long Length in_uitloop_Easydrain:Multi Long Length zijuitloop hoog 50mm, zij-ingang 40mm:...)
3070536
3083953

# IfcFlowTerminal: Multi Square horizontal outlet low 40mm (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi Square horizontal outlet low 40mm
Name (NLRS_PF_52_UN_Multi Square uitloop_Easydrain:Multi Square horizontal outlet low 40mm:...)
3072497
3083985

# IfcFlowTerminal: Multi Square zijuitloop hoog 50mm, zij-ingang 40mm (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi Square zijuitloop hoog 50mm, zij-ingang 40mm
Name (NLRS_PF_52_UN_Multi Square in_uitloop_Easydrain:Multi Square zijuitloop hoog 50mm, zij-ingang 40mm:...)
3072674
3083987

# IfcFlowTerminal: Multi TAF Wall horizontal outlet high 50mm, NLRS_PF_52_UN_Multi TAF Wall uitloop_Easydrain:Multi TAF Wall horizontal outlet high 50mm:3085097
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi TAF Wall horizontal outlet high 50mm

# IfcFlowTerminal: Multi TAF Wall horizontal outlet low 40mm (4)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi TAF Wall horizontal outlet low 40mm
Name (NLRS_PF_52_UN_Multi TAF Wall uitloop_Easydrain:Multi TAF Wall horizontal outlet low 40mm:...)
3058308
3072313
3083979
3084810

# IfcFlowTerminal: Multi TAF Wall horizontal outlet low 40mm, NLRS_PF_52_UN_Multi TAF Wall uitloop_Easydrain:Multi TAF Wall horizontal outlet low 40mm:3058367
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_n1_Asfalt_bitumen, NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi TAF Wall horizontal outlet low 40mm

# IfcFlowTerminal: Multi TAF Wall horizontal outlet low 50mm, NLRS_PF_52_UN_Multi TAF Wall uitloop_Easydrain:Multi TAF Wall horizontal outlet low 50mm:3084956
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_n1_Asfalt_bitumen, NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi TAF Wall horizontal outlet low 50mm

# IfcFlowTerminal: Multi TAF Wall onderuitloop 50mm, zij-ingang 40mm, NLRS_PF_52_UN_Multi TAF Wall in_uitloop_Easydrain:Multi TAF Wall onderuitloop 50mm, zij-ingang 40mm:3085331
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_n1_Asfalt_bitumen, NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi TAF Wall onderuitloop 50mm, zij-ingang 40mm

# IfcFlowTerminal: Multi TAF Wall onderuitloop 50mm, zij-ingang 50mm, NLRS_PF_52_UN_Multi TAF Wall in_uitloop_Easydrain:Multi TAF Wall onderuitloop 50mm, zij-ingang 50mm:3085383
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi TAF Wall onderuitloop 50mm, zij-ingang 50mm

# IfcFlowTerminal: Multi TAF Wall vertical outlet 50mm, NLRS_PF_52_UN_Multi TAF Wall uitloop_Easydrain:Multi TAF Wall vertical outlet 50mm:3085197
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_n1_Asfalt_bitumen, NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi TAF Wall vertical outlet 50mm

# IfcFlowTerminal: Multi TAF Wall zijuitloop hoog 50mm, zij-ingang 40mm (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi TAF Wall zijuitloop hoog 50mm, zij-ingang 40mm
Name (NLRS_PF_52_UN_Multi TAF Wall in_uitloop_Easydrain:Multi TAF Wall zijuitloop hoog 50mm, zij-ingang 40mm:...)
3058724
3085259

# IfcFlowTerminal: Multi TAF Wall zijuitloop hoog 50mm, zij-ingang 40mm (3)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_n1_Asfalt_bitumen, NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi TAF Wall zijuitloop hoog 50mm, zij-ingang 40mm
Name (NLRS_PF_52_UN_Multi TAF Wall in_uitloop_Easydrain:Multi TAF Wall zijuitloop hoog 50mm, zij-ingang 40mm:...)
3058727
3072389
3083982

# IfcFlowTerminal: Multi TAF horizontal outlet low 40mm (3)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi TAF horizontal outlet low 40mm
Name (NLRS_PF_52_UN_Multi TAF uitloop_Easydrain:Multi TAF horizontal outlet low 40mm:...)
3058130
3072080
3083973

# IfcFlowTerminal: Multi TAF horizontal outlet low 40mm, NLRS_PF_52_UN_Multi TAF uitloop_Easydrain:Multi TAF horizontal outlet low 40mm:3058213
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_n1_Asfalt_bitumen, NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi TAF horizontal outlet low 40mm

# IfcFlowTerminal: Multi TAF zijuitloop hoog 50mm, zij-ingang 40mm, NLRS_PF_52_UN_Multi TAF in_uitloop_Easydrain:Multi TAF zijuitloop hoog 50mm, zij-ingang 40mm:3058501
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi TAF zijuitloop hoog 50mm, zij-ingang 40mm

# IfcFlowTerminal: Multi TAF zijuitloop hoog 50mm, zij-ingang 40mm (3)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_n1_Asfalt_bitumen, NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi TAF zijuitloop hoog 50mm, zij-ingang 40mm
Name (NLRS_PF_52_UN_Multi TAF in_uitloop_Easydrain:Multi TAF zijuitloop hoog 50mm, zij-ingang 40mm:...)
3058588
3072145
3083976

# IfcFlowTerminal: Multi Tile horizontal outlet low 40mm (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_n1_Asfalt_bitumen, NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi Tile horizontal outlet low 40mm
Name (NLRS_PF_52_UN_Multi Tile uitloop_Easydrain:Multi Tile horizontal outlet low 40mm:...)
3070153
3083947

# IfcFlowTerminal: Multi Tile zijuitloop hoog 50mm, zij-ingang 40mm (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_n1_Asfalt_bitumen
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi Tile zijuitloop hoog 50mm, zij-ingang 40mm
Name (NLRS_PF_52_UN_Multi Tile in_uitloop_Easydrain:Multi Tile zijuitloop hoog 50mm, zij-ingang 40mm:...)
3070325
3083949

# IfcFlowTerminal: Multi Trapezium horizontal outlet low 40mm (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi Trapezium horizontal outlet low 40mm
Name (NLRS_PF_52_UN_Multi Trapezium uitloop_Easydrain:Multi Trapezium horizontal outlet low 40mm:...)
3072795
3083989

# IfcFlowTerminal: Multi Trapezium zijuitloop hoog 50mm, zij-ingang 40mm (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi Trapezium zijuitloop hoog 50mm, zij-ingang 40mm
Name (NLRS_PF_52_UN_Multi Trapezium in_uitloop_Easydrain:Multi Trapezium zijuitloop hoog 50mm, zij-ingang 40mm:...)
3072915
3083991

# IfcFlowTerminal: Multi horizontal outlet low 40mm (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_52_WPS_ EasyDrain, NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi horizontal outlet low 40mm
Name (NLRS_PF_52_UN_Multi uitloop_Easydrain:Multi horizontal outlet low 40mm:...)
3068590
3083926

# IfcFlowTerminal: Multi horizontal outlet low 40mm (4)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi horizontal outlet low 40mm
Name (NLRS_PF_52_UN_Multi uitloop_Easydrain:Multi horizontal outlet low 40mm:...)
3067914
3068656
3083923
3083929

# IfcFlowTerminal: Multi horizontal outlet low 50mm (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi horizontal outlet low 50mm
Name (NLRS_PF_52_UN_Multi uitloop_Easydrain:Multi horizontal outlet low 50mm:...)
3068809
3083932

# IfcFlowTerminal: Multi zijuitloop hoog 50mm, zij-ingang 40mm (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_52_WPS_ EasyDrain, NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi zijuitloop hoog 50mm, zij-ingang 40mm
Name (NLRS_PF_52_UN_Multi in_uitloop_Easydrain:Multi zijuitloop hoog 50mm, zij-ingang 40mm:...)
3069633
3083941

# IfcFlowTerminal: Multi zijuitloop hoog 50mm, zij-ingang 40mm (6)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Multi zijuitloop hoog 50mm, zij-ingang 40mm
Name (NLRS_PF_52_UN_Multi in_uitloop_Easydrain:Multi zijuitloop hoog 50mm, zij-ingang 40mm:...)
3069433
3069486
3069697
3083935
3083938
3083944

# IfcFlowTerminal: Round Flex Class (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Round Flex Class
Name (NLRS_PF_52_UN_Round Flex Class_Easydrain:Round Flex Class:...)
3073934
3084023

# IfcFlowTerminal: S-Line (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: S-Line
Name
NLRS_PF_52_UN_S-Line_Easydrain:S-Line:3086108
NLRS_PF_52_UN_Showerboard S-Line_Easydrain:S-Line:3373422

# IfcFlowTerminal: S-Line High, NLRS_PF_52_UN_S-Line TAF High_Easydrain:S-Line High:3086457
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: S-Line High

# IfcFlowTerminal: S-Line High met M2 ondiep sifonhuis, NLRS_PF_52_UN_S-Line TAF High_Easydrain:S-Line High met M2 ondiep sifonhuis:3086520
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: S-Line High met M2 ondiep sifonhuis

# IfcFlowTerminal: S-Line High met M2 sifonhuis onderuitloop, NLRS_PF_52_UN_S-Line TAF High_Easydrain:S-Line High met M2 sifonhuis onderuitloop:3086606
