Properties of the parts of a building model (IFC2X3), part 8 of 9

# IfcFlowTerminal: Vinyl M2-35, NLRS_PF_52_UN_Vinyl_Easydrain:Vinyl M2-35:3064626
Other - Outlet angle: 90 deg; build_in_depth calculated: 50 mm; Draingoot Depth: 30 mm; Draingoot Width: 89 mm; Drain length: 80 mm; Drains_number: 6; Drains_total length: 617 mm; Drains d2d: 20 mm; Family: NLRS_PF_52_UN_Vinyl_Easydrain: Vinyl M2-35; Family and Type: NLRS_PF_52_UN_Vinyl_Easydrain: Vinyl M2-35; Flange Width: 132 mm; Grate With: 63 mm; L_/_: 21.5 mm; Leg length: 50 mm; Length Calculated: 700 mm; M2_35_siphon: yes; M2_50_siphon: no; m2_vertical: no; max_length: 1200 mm; min_length: 700 mm; Outlet_pos_length: 25 mm; Outlet_pos_width: 25 mm; Outlet depth: 54 mm; Outlet length: 150 mm; ref_line_angle: 180 deg; Ro: 20 mm; Ro1: 44.5 mm; Siphon Depth: 54 mm; Siphon Length: 210 mm; Siphon Width: 120 mm; Tile_thickness_calculated: 5 mm; Tile Thickness: 5 mm; Type: NLRS_PF_52_UN_Vinyl_Easydrain: Vinyl M2-35; Type Id: NLRS_PF_52_UN_Vinyl_Easydrain: Vinyl M2-35
Phasing - Phase Created: New Construction

# IfcFlowTerminal: Vinyl M2-50, NLRS_PF_52_UN_Vinyl_Easydrain:Vinyl M2-50:3064747
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Vinyl; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Vinyl M2-50; URL: https://www.easydrain.nl/douchegoten/vinyl/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Vinyl_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Vinyl M2-50
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Build-in-Depth: 69 mm; Grate Length: 750 mm; Host: Level : Level 1
Dimensions - Do: 50 mm; Do1: 89 mm; NLRS_C_breedte: 89 mm; NLRS_C_hoogte: 69 mm; NLRS_C_lengte: 700 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.00383939 m3
Identity Data - Mark: 1604; NLRS_C_code_product: EDVIN-M2- 700-50; NLRS_C_omschrijving: Vinyl
Mechanical - System Classification: Sanitary
Other - Outlet angle: 90 deg; Drains_number: 6; m2_vertical: no; ref_line_angle: 180 deg; build_in_depth calculated: 69 mm; Draingoot Depth: 30 mm; Draingoot Width: 89 mm; Drain length: 80 mm; Drains_total length: 617 mm; Drains d2d: 20 mm; Family: NLRS_PF_52_UN_Vinyl_Easydrain: Vinyl M2-50; Family and Type: NLRS_PF_52_UN_Vinyl_Easydrain: Vinyl M2-50; Flange Width: 132 mm; Grate With: 63 mm; L_/_: 21.5 mm; Leg length: 69 mm; Length Calculated: 700 mm; M2_35_siphon: no; M2_50_siphon: yes; max_length: 1200 mm; min_length: 700 mm; Outlet_pos_length: 25 mm; Outlet_pos_width: 25 mm; Outlet depth: 75 mm; Outlet length: 168 mm; Ro: 25 mm; Ro1: 44.5 mm; Siphon Depth: 75 mm; Siphon Length: 216 mm; Siphon Width: 120 mm; Tile_thickness_calculated: 5 mm; Tile Thickness: 5 mm; Type: NLRS_PF_52_UN_Vinyl_Easydrain: Vinyl M2-50; Type Id: NLRS_PF_52_UN_Vinyl_Easydrain: Vinyl M2-50
Phasing - Phase Created: New Construction

# IfcFlowTerminal: Vinyl M2-50 with M2 vertical outlet, NLRS_PF_52_UN_Vinyl_Easydrain:Vinyl M2-50 with M2 vertical outlet:3064866
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot verticale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Vinyl; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Vinyl M2-50 with M2 vertical outlet; URL: https://www.easydrain.nl/douchegoten/vinyl/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Vinyl_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Vinyl M2-50 with M2 vertical outlet
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Build-in-Depth: 69 mm; Grate Length: 750 mm; Host: Level : Level 1
Dimensions - Do: 50 mm; Do1: 89 mm; NLRS_C_breedte: 89 mm; NLRS_C_hoogte: 69 mm; NLRS_C_lengte: 700 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.00383939 m3
Identity Data - Mark: 1605; NLRS_C_code_product: EDVIN-M2- 700-50; NLRS_C_omschrijving: Vinyl
Mechanical - System Classification: Sanitary
Other - Outlet angle: 180 deg; Drains_number: 6; M2_50_siphon: no; ref_line_angle: 180 deg; M2_35_siphon: no; build_in_depth calculated: 69 mm; Draingoot Depth: 30 mm; Draingoot Width: 89 mm; Drain length: 80 mm; Drains_total length: 617 mm; Drains d2d: 20 mm; Family: NLRS_PF_52_UN_Vinyl_Easydrain: Vinyl M2-50 with M2 vertical outlet; Family and Type: NLRS_PF_52_UN_Vinyl_Easydrain: Vinyl M2-50 with M2 vertical outlet; Flange Width: 132 mm; Grate With: 63 mm; L_/_: 21.5 mm; Leg length: 69 mm; Length Calculated: 700 mm; m2_vertical: yes; max_length: 1200 mm; min_length: 700 mm; Outlet_pos_length: 25 mm; Outlet_pos_width: 0 mm; Outlet depth: 30 mm; Outlet length: 213 mm; Ro: 25 mm; Ro1: 44.5 mm; Siphon Depth: 75 mm; Siphon Length: 210 mm; Siphon Width: 120 mm; Tile_thickness_calculated: 5 mm; Tile Thickness: 5 mm; Type: NLRS_PF_52_UN_Vinyl_Easydrain: Vinyl M2-50 with M2 vertical outlet; Type Id: NLRS_PF_52_UN_Vinyl_Easydrain: Vinyl M2-50 with M2 vertical outlet
Phasing - Phase Created: New Construction

# IfcFlowTerminal: WTW Aqua, NLRS_PF_52_UN_WTW systeem Aqua grate_Easydrain:WTW Aqua:3153924
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: Roestvrijstaal, geborsteld, ISR_groen
Type - Dimensions - NLRS_C_breedte: 130 mm; NLRS_C_hoogte: 90 mm; NLRS_C_lengte: 650 mm; NLRS_P_c01_diameter: 40 mm; NLRS_P_c02_buiten_diameter: 21.3 mm; NLRS_P_c02_diameter: 15 mm
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: WTW System; Manufacturer: Easy Sanitary Solutions; Model: WTW System; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_C_code_product: ED-WTW; NLRS_C_omschrijving: WTW Systeem Aqua; NLRS_P_c01_aansluitmethode: Lijmverbinding; NLRS_P_c02_aansluitmethode: Draadverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: WTW Aqua; URL: https://www.easydrain.nl/douchegoten/wtw-systeem/
Type - Materials and Finishes - NLRS_C_materiaal: ISR_groen
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_WTW systeem Aqua grate_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: WTW Aqua
Constraints - Level: Level: Level 1; Offset: 0 mm; Aqua Grate Type: quatro; Grate Dimension: 146 mm; Height Connection: 0 mm; Host: Level : Level 1; Tile Thickness: 16 mm
Dimensions - Volume: 0.00709114 m3
Identity Data - Design Option: Main Model; Mark: 2505
Mechanical - System Classification: Sanitary
Other - Family: NLRS_PF_52_UN_WTW systeem Aqua grate_Easydrain: WTW Aqua; Family and Type: NLRS_PF_52_UN_WTW systeem Aqua grate_Easydrain: WTW Aqua; Height_connection_calculated: 0 mm; Height Void: 55 mm; Type: NLRS_PF_52_UN_WTW systeem Aqua grate_Easydrain: WTW Aqua; Type Id: NLRS_PF_52_UN_WTW systeem Aqua grate_Easydrain: WTW Aqua
Phasing - Phase Created: New Construction

# IfcFlowTerminal: WTW Multi, NLRS_PF_52_UN_WTW systeem Multi grate_Easydrain:WTW Multi:3153974
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, ISR_groen
Type - Dimensions - NLRS_C_breedte: 130 mm; NLRS_C_hoogte: 90 mm; NLRS_C_lengte: 650 mm; NLRS_P_c01_diameter: 40 mm; NLRS_P_c02_buiten_diameter: 21.3 mm; NLRS_P_c02_diameter: 15 mm
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: WTW System; Manufacturer: Easy Sanitary Solutions; Model: WTW System; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_C_code_product: ED-WTW; NLRS_C_omschrijving: WTW Systeem Multi; NLRS_P_c01_aansluitmethode: Lijmverbinding; NLRS_P_c02_aansluitmethode: Draadverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: WTW Multi; URL: https://www.easydrain.nl/douchegoten/wtw-systeem/
Type - Materials and Finishes - NLRS_C_materiaal: ISR_groen
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_WTW systeem Multi grate_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: WTW Multi
Constraints - Level: Level: Level 1; Offset: 0 mm; Grate Length: 900 mm; Height Connection: 50 mm; Host: Level : Level 1; Multi Grate Type: Multi Fixt; Tile Thickness: 7 mm
Dimensions - Volume: 0.00737922 m3
Identity Data - Mark: 2506
Mechanical - System Classification: Sanitary,Other
Other - Family: NLRS_PF_52_UN_WTW systeem Multi grate_Easydrain: WTW Multi; Family and Type: NLRS_PF_52_UN_WTW systeem Multi grate_Easydrain: WTW Multi; Height Connection Calculated: 50 mm; Height Void: 55 mm; Type: NLRS_PF_52_UN_WTW systeem Multi grate_Easydrain: WTW Multi; Type Id: NLRS_PF_52_UN_WTW systeem Multi grate_Easydrain: WTW Multi
Phasing - Phase Created: New Construction

# IfcFlowTerminal: White Glass 10x10 (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_52_WPS_ EasyDrain, NLRS_o_Glas_wit, Roestvrijstaal,geborsteld
Type - Dimensions - Grate Length: 100 mm; Grate Width: 100 mm
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Aqua Jewels Quatro; Manufacturer: Easy Sanitary Solutions; Model: Aqua Jewels Quatro; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: White Glass 10x10; URL: https://www.easydrain.nl/doucheputten/aqua-jewels-quattro/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: NLRS_o_Glas_wit
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: White Glass 10x10
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm; WPS: yes; Host: Level : Level 1; Tile Thickness: 5 mm
Dimensions - Flange length: 160 mm; Flange width: 160 mm; Grate Depth: 20 mm; NLRS_C_breedte: 100 mm; NLRS_C_lengte: 100 mm; Volume: 0.0005105 m3
Identity Data - NLRS_C_code_product: AJQ-10X10-GW; NLRS_C_omschrijving: Aqua Jewels Quatro - White Glass
Other - offset_length: 0 mm; offset_width: 0 mm; Tile: yes; Family: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: White Glass 10x10; Family and Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: White Glass 10x10; s: 5 mm; Tile_Thickness_calculated: 5 mm; Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: White Glass 10x10; Type Id: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: White Glass 10x10; WPS Length: 330 mm
Phasing - Phase Created: New Construction
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain:White Glass 10x10:...) | Build-in-Depth (mm) = NLRS_C_hoogte (mm) = Build_in_depth_calculated (mm) | Mark
3053144 | 59 | 1081 | Identity Data - Design Option: Main Model
3053462 | 90 | 1180 | Identity Data - Design Option: Main Model
3060110 | 59 | 1352
3060155 | 90 | 1397
3064970 | 59 | 1636
3065015 | 90 | 1681 | Identity Data - Design Option: Main Model
3083472 | 59 | 2061 | Identity Data - Design Option: Main Model
3083517 | 90 | 2106

# IfcFlowTerminal: White Glass 15x15 (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_52_WPS_ EasyDrain, NLRS_o_Glas_wit, Roestvrijstaal,geborsteld
Type - Dimensions - Grate Length: 150 mm; Grate Width: 150 mm
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Aqua Jewels Quatro; Manufacturer: Easy Sanitary Solutions; Model: Aqua Jewels Quatro; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: White Glass 15x15; URL: https://www.easydrain.nl/doucheputten/aqua-jewels-quattro/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: NLRS_o_Glas_wit
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: White Glass 15x15
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm; WPS: yes; Host: Level : Level 1; Tile Thickness: 5 mm
Dimensions - Flange length: 210 mm; Flange width: 210 mm; Grate Depth: 20 mm; NLRS_C_breedte: 150 mm; NLRS_C_lengte: 150 mm; Volume: 0.000855 m3
Identity Data - NLRS_C_code_product: AJQ-15X15-GW; NLRS_C_omschrijving: Aqua Jewels Quatro - White Glass
Other - Tile: yes; Family: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: White Glass 15x15; Family and Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: White Glass 15x15; offset_length: 5 mm; offset_width: 10 mm; s: 5 mm; Tile_Thickness_calculated: 5 mm; Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: White Glass 15x15; Type Id: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: White Glass 15x15; WPS Length: 330 mm
Phasing - Phase Created: New Construction
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain:White Glass 15x15:...) | Build-in-Depth (mm) = NLRS_C_hoogte (mm) = Build_in_depth_calculated (mm) | Mark
3053147 | 59 | 1084
3053465 | 90 | 1183
3060113 | 59 | 1355
3060158 | 90 | 1400 | Identity Data - Design Option: Main Model
3064973 | 59 | 1639
3065018 | 90 | 1684 | Identity Data - Design Option: Main Model
3083475 | 59 | 2064
3083520 | 90 | 2109 | Identity Data - Design Option: Main Model

# IfcFlowTerminal: White Glass 20x20 (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_52_WPS_ EasyDrain, NLRS_o_Glas_wit, Roestvrijstaal,geborsteld
Type - Dimensions - Grate Length: 200 mm; Grate Width: 200 mm
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Aqua Jewels Quatro; Manufacturer: Easy Sanitary Solutions; Model: Aqua Jewels Quatro; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: White Glass 20x20; URL: https://www.easydrain.nl/doucheputten/aqua-jewels-quattro/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: NLRS_o_Glas_wit
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: White Glass 20x20
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm; WPS: yes; Host: Level : Level 1; Tile Thickness: 5 mm
Dimensions - Flange length: 260 mm; Flange width: 260 mm; Grate Depth: 20 mm; NLRS_C_breedte: 200 mm; NLRS_C_lengte: 200 mm; Volume: 0.0013345 m3
Identity Data - NLRS_C_code_product: AJQ-20X20-GW; NLRS_C_omschrijving: Aqua Jewels Quatro - White Glass
Other - Tile: yes; Family: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: White Glass 20x20; Family and Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: White Glass 20x20; offset_length: 5 mm; offset_width: 10 mm; s: 5 mm; Tile_Thickness_calculated: 5 mm; Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: White Glass 20x20; Type Id: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: White Glass 20x20; WPS Length: 330 mm
Phasing - Phase Created: New Construction
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain:White Glass 20x20:...) | Build-in-Depth (mm) = NLRS_C_hoogte (mm) = Build_in_depth_calculated (mm) | Mark
3053150 | 59 | 1087 | Identity Data - Design Option: Main Model
3053468 | 90 | 1186
3060116 | 59 | 1358 | Identity Data - Design Option: Main Model
3060161 | 90 | 1403 | Identity Data - Design Option: Main Model
3064976 | 59 | 1642
3065021 | 90 | 1687
3083478 | 59 | 2067
3083523 | 90 | 2112

# IfcFlowTerminal: XS Nano (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: XS Nano; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: XS Nano; URL: https://www.easydrain.nl/douchegoten/nano/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_XS Nano_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: XS Nano
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Build-in-Depth: 66 mm; Grate Length: 800 mm; Host: Level : Level 1; Tile Thickness: 5 mm
Dimensions - Do: 50 mm; Do1: 50 mm; NLRS_C_breedte: 40 mm; NLRS_C_hoogte: 66 mm; NLRS_C_lengte: 800 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.0024817 m3
Identity Data - Design Option: Main Model; NLRS_C_code_product: Nano-Line- 800; NLRS_C_omschrijving: XS Nano
Mechanical - System Classification: Sanitary
Other - Outlet angle: 90 deg; m2_vertical: no; build_in_depth_calculated: 66 mm; Draingoot Depth: 24 mm; Draingoot Width: 40 mm; Family: NLRS_PF_52_UN_XS Nano_Easydrain: XS Nano; Family and Type: NLRS_PF_52_UN_XS Nano_Easydrain: XS Nano; Flange Width: 70 mm; L_/_: 17.5 mm; Leg length: 66 mm; Length_calculated: 800 mm; m2_flat: no; max_length: 1200 mm; min_length: 800 mm; Outlet_pos_length: 25 mm; Outlet_pos_width: 25 mm; Outlet depth: 69 mm; Outlet Length: 168 mm; Ref_line_angle: 180 deg; Ro: 25 mm; Ro1: 25 mm; Siphon Connection: yes; Siphon Depth: 66 mm; Siphon Width: 120 mm; standard_siphon: yes; Tile_thickness_calculated: 5 mm; Tile length: 60 mm; Type: NLRS_PF_52_UN_XS Nano_Easydrain: XS Nano; Type Id: NLRS_PF_52_UN_XS Nano_Easydrain: XS Nano
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_XS Nano_Easydrain:XS Nano:...) | Mark
3074293 | 1935
3084028 | 2380

# IfcFlowTerminal: XS Nano Wall (3)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: XS Nano Wall; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: XS Nano Wall; URL: https://www.easydrain.nl/douchegoten/nano-wall/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_XS Nano Wall_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: XS Nano Wall
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Build-in-Depth: 66 mm; Grate Length: 800 mm; Host: Level : Level 1; Tile Thickness: 5 mm
Dimensions - Do: 50 mm; Do1: 50 mm; NLRS_C_breedte: 53 mm; NLRS_C_hoogte: 66 mm; NLRS_C_lengte: 800 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.0026573 m3
Identity Data - Design Option: Main Model; NLRS_C_code_product: Nano-Line-W- 800; NLRS_C_omschrijving: XS Nano Wall
Mechanical - System Classification: Sanitary
Other - Outlet angle: 90 deg; m2_vertical: no; m2_flat: no; Ref_line_angle: 180 deg; Siphon Connection: yes; standard_siphon: yes; build_in_depth_calculated: 66 mm; Draingoot Depth: 24 mm; Draingoot Width: 53 mm; Family: NLRS_PF_52_UN_XS Nano Wall_Easydrain: XS Nano Wall; Family and Type: NLRS_PF_52_UN_XS Nano Wall_Easydrain: XS Nano Wall; Flange Width: 70 mm; L_/_: 17.5 mm; Leg length: 66 mm; Length_calculated: 800 mm; max_length: 1200 mm; min_length: 800 mm; Outlet_pos_length: 25 mm; Outlet_pos_width: 25 mm; Outlet depth: 69 mm; Outlet Length: 168 mm; Ro: 25 mm; Ro1: 25 mm; Siphon Depth: 66 mm; Siphon Width: 120 mm; Tile_thickness_calculated: 5 mm; Tile length: 60 mm; Type: NLRS_PF_52_UN_XS Nano Wall_Easydrain: XS Nano Wall; Type Id: NLRS_PF_52_UN_XS Nano Wall_Easydrain: XS Nano Wall
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_XS Nano Wall_Easydrain:XS Nano Wall:...) | Mark
3074323 | 1940
3084033 | 2385
3962055 | 2700

# IfcFlowTerminal: XS Nano Wall with M2 flat siphon (3)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: XS Nano Wall; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: XS Nano Wall with M2 flat siphon; URL: https://www.easydrain.nl/douchegoten/nano-wall/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_XS Nano Wall_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: XS Nano Wall with M2 flat siphon
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Build-in-Depth: 66 mm; Grate Length: 800 mm; Host: Level : Level 1; Tile Thickness: 5 mm
Dimensions - Do: 40 mm; Do1: 50 mm; NLRS_C_breedte: 53 mm; NLRS_C_hoogte: 66 mm; NLRS_C_lengte: 800 mm; NLRS_P_c01_diameter: 40 mm; Volume: 0.00258888 m3
Identity Data - Design Option: Main Model; NLRS_C_code_product: Nano-Line-W- 800; NLRS_C_omschrijving: XS Nano Wall
Mechanical - System Classification: Sanitary
Other - Outlet angle: 90 deg; m2_vertical: no; Ref_line_angle: 180 deg; m2_flat: yes; Siphon Connection: no; standard_siphon: no; build_in_depth_calculated: 66 mm; Draingoot Depth: 24 mm; Draingoot Width: 53 mm; Family: NLRS_PF_52_UN_XS Nano Wall_Easydrain: XS Nano Wall with M2 flat siphon; Family and Type: NLRS_PF_52_UN_XS Nano Wall_Easydrain: XS Nano Wall with M2 flat siphon; Flange Width: 70 mm; L_/_: 17.5 mm; Leg length: 66 mm; Length_calculated: 800 mm; max_length: 1200 mm; min_length: 800 mm; Outlet_pos_length: 25 mm; Outlet_pos_width: 25 mm; Outlet depth: 44 mm; Outlet Length: 175 mm; Ro: 20 mm; Ro1: 25 mm; Siphon Depth: 66 mm; Siphon Width: 120 mm; Tile_thickness_calculated: 5 mm; Tile length: 60 mm; Type: NLRS_PF_52_UN_XS Nano Wall_Easydrain: XS Nano Wall with M2 flat siphon; Type Id: NLRS_PF_52_UN_XS Nano Wall_Easydrain: XS Nano Wall with M2 flat siphon
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_XS Nano Wall_Easydrain:XS Nano Wall with M2 flat siphon:...) | Mark
3074331 | 1941
3084034 | 2386
3962056 | 2701

# IfcFlowTerminal: XS Nano Wall with M2 vertical outlet (3)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot verticale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: XS Nano Wall; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: XS Nano Wall with M2 vertical outlet; URL: https://www.easydrain.nl/douchegoten/nano-wall/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_XS Nano Wall_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: XS Nano Wall with M2 vertical outlet
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Build-in-Depth: 66 mm; Grate Length: 800 mm; Host: Level : Level 1; Tile Thickness: 5 mm
Dimensions - Do: 50 mm; Do1: 50 mm; NLRS_C_breedte: 53 mm; NLRS_C_hoogte: 66 mm; NLRS_C_lengte: 800 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.0026573 m3
Identity Data - NLRS_C_code_product: Nano-Line-W- 800; NLRS_C_omschrijving: XS Nano Wall
Mechanical - System Classification: Sanitary
Other - Outlet angle: 180 deg; m2_vertical: yes; m2_flat: no; Ref_line_angle: 180 deg; Siphon Connection: yes; standard_siphon: no; build_in_depth_calculated: 66 mm; Draingoot Depth: 24 mm; Draingoot Width: 53 mm; Family: NLRS_PF_52_UN_XS Nano Wall_Easydrain: XS Nano Wall with M2 vertical outlet; Family and Type: NLRS_PF_52_UN_XS Nano Wall_Easydrain: XS Nano Wall with M2 vertical outlet; Flange Width: 70 mm; L_/_: 17.5 mm; Leg length: 66 mm; Length_calculated: 800 mm; max_length: 1200 mm; min_length: 800 mm; Outlet_pos_length: 25 mm; Outlet_pos_width: 50 mm; Outlet depth: 24 mm; Outlet Length: 213 mm; Ro: 25 mm; Ro1: 25 mm; Siphon Depth: 66 mm; Siphon Width: 120 mm; Tile_thickness_calculated: 5 mm; Tile length: 60 mm; Type: NLRS_PF_52_UN_XS Nano Wall_Easydrain: XS Nano Wall with M2 vertical outlet; Type Id: NLRS_PF_52_UN_XS Nano Wall_Easydrain: XS Nano Wall with M2 vertical outlet
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_XS Nano Wall_Easydrain:XS Nano Wall with M2 vertical outlet:...) | Mark | Design Option
3074341 | 1943
3084036 | 2388 | Main Model
3962058 | 2703 | Main Model

# IfcFlowTerminal: XS Nano with M2 flat siphon (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: XS Nano; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: XS Nano with M2 flat siphon; URL: https://www.easydrain.nl/douchegoten/nano/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_XS Nano_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: XS Nano with M2 flat siphon
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Build-in-Depth: 66 mm; Grate Length: 800 mm; Host: Level : Level 1; Tile Thickness: 5 mm
Dimensions - Do: 40 mm; Do1: 50 mm; NLRS_C_breedte: 40 mm; NLRS_C_hoogte: 66 mm; NLRS_C_lengte: 800 mm; NLRS_P_c01_diameter: 40 mm; Volume: 0.00241328 m3
Identity Data - NLRS_C_code_product: Nano-Line- 800; NLRS_C_omschrijving: XS Nano
Mechanical - System Classification: Sanitary
Other - Outlet angle: 90 deg; m2_vertical: no; Ref_line_angle: 180 deg; build_in_depth_calculated: 66 mm; Draingoot Depth: 24 mm; Draingoot Width: 40 mm; Family: NLRS_PF_52_UN_XS Nano_Easydrain: XS Nano with M2 flat siphon; Family and Type: NLRS_PF_52_UN_XS Nano_Easydrain: XS Nano with M2 flat siphon; Flange Width: 70 mm; L_/_: 17.5 mm; Leg length: 66 mm; Length_calculated: 800 mm; m2_flat: yes; max_length: 1200 mm; min_length: 800 mm; Outlet_pos_length: 25 mm; Outlet_pos_width: 25 mm; Outlet depth: 44 mm; Outlet Length: 175 mm; Ro: 20 mm; Ro1: 25 mm; Siphon Connection: no; Siphon Depth: 66 mm; Siphon Width: 120 mm; standard_siphon: no; Tile_thickness_calculated: 5 mm; Tile length: 60 mm; Type: NLRS_PF_52_UN_XS Nano_Easydrain: XS Nano with M2 flat siphon; Type Id: NLRS_PF_52_UN_XS Nano_Easydrain: XS Nano with M2 flat siphon
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_XS Nano_Easydrain:XS Nano with M2 flat siphon:...) | Mark
3074301 | 1936
3084029 | 2381

# IfcFlowTerminal: XS Nano with M2 vertical outlet (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot verticale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: XS Nano; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: XS Nano with M2 vertical outlet; URL: https://www.easydrain.nl/douchegoten/nano/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_XS Nano_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: XS Nano with M2 vertical outlet
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Build-in-Depth: 66 mm; Grate Length: 800 mm; Host: Level : Level 1; Tile Thickness: 5 mm
Dimensions - Do: 50 mm; Do1: 50 mm; NLRS_C_breedte: 40 mm; NLRS_C_hoogte: 66 mm; NLRS_C_lengte: 800 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.0024817 m3
Identity Data - NLRS_C_code_product: Nano-Line- 800; NLRS_C_omschrijving: XS Nano
Mechanical - System Classification: Sanitary
Other - Outlet angle: 180 deg; m2_vertical: yes; m2_flat: no; Ref_line_angle: 180 deg; Siphon Connection: yes; standard_siphon: no; build_in_depth_calculated: 66 mm; Draingoot Depth: 24 mm; Draingoot Width: 40 mm; Family: NLRS_PF_52_UN_XS Nano_Easydrain: XS Nano with M2 vertical outlet; Family and Type: NLRS_PF_52_UN_XS Nano_Easydrain: XS Nano with M2 vertical outlet; Flange Width: 70 mm; L_/_: 17.5 mm; Leg length: 66 mm; Length_calculated: 800 mm; max_length: 1200 mm; min_length: 800 mm; Outlet_pos_length: 25 mm; Outlet_pos_width: 50 mm; Outlet depth: 24 mm; Outlet Length: 213 mm; Ro: 25 mm; Ro1: 25 mm; Siphon Depth: 66 mm; Siphon Width: 120 mm; Tile_thickness_calculated: 5 mm; Tile length: 60 mm; Type: NLRS_PF_52_UN_XS Nano_Easydrain: XS Nano with M2 vertical outlet; Type Id: NLRS_PF_52_UN_XS Nano_Easydrain: XS Nano with M2 vertical outlet
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_XS Nano_Easydrain:XS Nano with M2 vertical outlet:...) | Mark
3074311 | 1938
3084031 | 2383 | Identity Data - Design Option: Main Model

# IfcFlowTerminal: XS-Z1 Brushed (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: XS Z-1; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: XS-Z1 Brushed; URL: https://www.easydrain.nl/douchegoten/xs-design-z-1/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_XS Z1 Complete Set_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: XS-Z1 Brushed
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Build-in-Depth: 66 mm; Grate Length: 900 mm; Host: Level : Level 1; Tile Thickness: 5 mm
Dimensions - Do: 50 mm; Do1: 50 mm; NLRS_C_breedte: 36 mm; NLRS_C_hoogte: 66 mm; NLRS_C_lengte: 900 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.00257242 m3
Identity Data - NLRS_C_code_product: XS-TAF-900-Z1M; NLRS_C_omschrijving: XS-Z1 - Brushed Stainless Steel
Mechanical - System Classification: Sanitary
Other - Outlet angle: 90 deg; m2_vertical: no; m2_flat: no; Ref_line_angle: 180 deg; Siphon Connection: yes; standard_siphon: yes; build_in_depth_calculated: 66 mm; Draingoot Depth: 24 mm; Draingoot Width: 36 mm; Family: NLRS_PF_52_UN_XS Z1 Complete Set_Easydrain: XS-Z1 Brushed; Family and Type: NLRS_PF_52_UN_XS Z1 Complete Set_Easydrain: XS-Z1 Brushed; Flange Width: 70 mm; L_/_: 17.5 mm; Leg length: 66 mm; Length_calculated: 900 mm; max_length: 2000 mm; min_length: 200 mm; Outlet_pos_length: 25 mm; Outlet_pos_width: 25 mm; Outlet depth: 69 mm; Outlet Length: 168 mm; Ro: 25 mm; Ro1: 25 mm; Siphon Depth: 66 mm; Siphon Width: 120 mm; Tile_thickness_calculated: 5 mm; Type: NLRS_PF_52_UN_XS Z1 Complete Set_Easydrain: XS-Z1 Brushed; Type Id: NLRS_PF_52_UN_XS Z1 Complete Set_Easydrain: XS-Z1 Brushed
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_XS Z1 Complete Set_Easydrain:XS-Z1 Brushed:...) | Mark
3078751 | 1950 | Identity Data - Design Option: Main Model
3084038 | 2390

# IfcFlowTerminal: XS-Z1 Brushed with M2 flat siphon (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: XS Z-1; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: XS-Z1 Brushed with M2 flat siphon; URL: https://www.easydrain.nl/douchegoten/xs-design-z-1/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_XS Z1 Complete Set_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: XS-Z1 Brushed with M2 flat siphon
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Build-in-Depth: 66 mm; Grate Length: 900 mm; Host: Level : Level 1; Tile Thickness: 5 mm
Dimensions - Do: 40 mm; Do1: 50 mm; NLRS_C_breedte: 36 mm; NLRS_C_hoogte: 66 mm; NLRS_C_lengte: 900 mm; NLRS_P_c01_diameter: 40 mm; Volume: 0.002504 m3
Identity Data - Design Option: Main Model; NLRS_C_code_product: XS-TAF-900-Z1M; NLRS_C_omschrijving: XS-Z1 - Brushed Stainless Steel
Mechanical - System Classification: Sanitary
Other - Outlet angle: 90 deg; m2_vertical: no; Ref_line_angle: 180 deg; m2_flat: yes; Siphon Connection: no; standard_siphon: no; build_in_depth_calculated: 66 mm; Draingoot Depth: 24 mm; Draingoot Width: 36 mm; Family: NLRS_PF_52_UN_XS Z1 Complete Set_Easydrain: XS-Z1 Brushed with M2 flat siphon; Family and Type: NLRS_PF_52_UN_XS Z1 Complete Set_Easydrain: XS-Z1 Brushed with M2 flat siphon; Flange Width: 70 mm; L_/_: 17.5 mm; Leg length: 66 mm; Length_calculated: 900 mm; max_length: 2000 mm; min_length: 200 mm; Outlet_pos_length: 25 mm; Outlet_pos_width: 25 mm; Outlet depth: 44 mm; Outlet Length: 175 mm; Ro: 20 mm; Ro1: 25 mm; Siphon Depth: 66 mm; Siphon Width: 120 mm; Tile_thickness_calculated: 5 mm; Type: NLRS_PF_52_UN_XS Z1 Complete Set_Easydrain: XS-Z1 Brushed with M2 flat siphon; Type Id: NLRS_PF_52_UN_XS Z1 Complete Set_Easydrain: XS-Z1 Brushed with M2 flat siphon
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_XS Z1 Complete Set_Easydrain:XS-Z1 Brushed with M2 flat siphon:...) | Mark
3078756 | 1951
3084039 | 2391

# IfcFlowTerminal: XS-Z1 Brushed with M2 vertical outlet (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot verticale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: XS Z-1; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: XS-Z1 Brushed with M2 vertical outlet; URL: https://www.easydrain.nl/douchegoten/xs-design-z-1/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_XS Z1 Complete Set_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: XS-Z1 Brushed with M2 vertical outlet
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Build-in-Depth: 66 mm; Grate Length: 900 mm; Host: Level : Level 1; Tile Thickness: 5 mm
Dimensions - Do: 50 mm; Do1: 50 mm; NLRS_C_breedte: 36 mm; NLRS_C_hoogte: 66 mm; NLRS_C_lengte: 900 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.00257242 m3
Identity Data - NLRS_C_code_product: XS-TAF-900-Z1M; NLRS_C_omschrijving: XS-Z1 - Brushed Stainless Steel
Mechanical - System Classification: Sanitary
Other - Outlet angle: 180 deg; m2_vertical: yes; m2_flat: no; Ref_line_angle: 180 deg; Siphon Connection: yes; standard_siphon: no; build_in_depth_calculated: 66 mm; Draingoot Depth: 24 mm; Draingoot Width: 36 mm; Family: NLRS_PF_52_UN_XS Z1 Complete Set_Easydrain: XS-Z1 Brushed with M2 vertical outlet; Family and Type: NLRS_PF_52_UN_XS Z1 Complete Set_Easydrain: XS-Z1 Brushed with M2 vertical outlet; Flange Width: 70 mm; L_/_: 17.5 mm; Leg length: 66 mm; Length_calculated: 900 mm; max_length: 2000 mm; min_length: 200 mm; Outlet_pos_length: 25 mm; Outlet_pos_width: 50 mm; Outlet depth: 24 mm; Outlet Length: 213 mm; Ro: 25 mm; Ro1: 25 mm; Siphon Depth: 66 mm; Siphon Width: 120 mm; Tile_thickness_calculated: 5 mm; Type: NLRS_PF_52_UN_XS Z1 Complete Set_Easydrain: XS-Z1 Brushed with M2 vertical outlet; Type Id: NLRS_PF_52_UN_XS Z1 Complete Set_Easydrain: XS-Z1 Brushed with M2 vertical outlet
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_XS Z1 Complete Set_Easydrain:XS-Z1 Brushed with M2 vertical outlet:...) | Mark
3078761 | 1952
3084040 | 2392 | Identity Data - Design Option: Main Model

# IfcFlowTerminal: XS-Z1 Chrome Plated (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_verchroomt
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: XS Z-1; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: XS-Z1 Chrome Plated; URL: https://www.easydrain.nl/douchegoten/xs-design-z-1/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_verchroomt
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_XS Z1 Complete Set_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: XS-Z1 Chrome Plated
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Build-in-Depth: 66 mm; Grate Length: 900 mm; Host: Level : Level 1; Tile Thickness: 5 mm
Dimensions - Do: 50 mm; Do1: 50 mm; NLRS_C_breedte: 36 mm; NLRS_C_hoogte: 66 mm; NLRS_C_lengte: 900 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.00257242 m3
Identity Data - NLRS_C_code_product: XS-TAF 900-Z1P; NLRS_C_omschrijving: XS-Z1 - Chrome Plated Steel
Mechanical - System Classification: Sanitary
Other - Outlet angle: 90 deg; m2_vertical: no; m2_flat: no; Ref_line_angle: 180 deg; Siphon Connection: yes; standard_siphon: yes; build_in_depth_calculated: 66 mm; Draingoot Depth: 24 mm; Draingoot Width: 36 mm; Family: NLRS_PF_52_UN_XS Z1 Complete Set_Easydrain: XS-Z1 Chrome Plated; Family and Type: NLRS_PF_52_UN_XS Z1 Complete Set_Easydrain: XS-Z1 Chrome Plated; Flange Width: 70 mm; L_/_: 17.5 mm; Leg length: 66 mm; Length_calculated: 900 mm; max_length: 1200 mm; min_length: 200 mm; Outlet_pos_length: 25 mm; Outlet_pos_width: 25 mm; Outlet depth: 69 mm; Outlet Length: 168 mm; Ro: 25 mm; Ro1: 25 mm; Siphon Depth: 66 mm; Siphon Width: 120 mm; Tile_thickness_calculated: 5 mm; Type: NLRS_PF_52_UN_XS Z1 Complete Set_Easydrain: XS-Z1 Chrome Plated; Type Id: NLRS_PF_52_UN_XS Z1 Complete Set_Easydrain: XS-Z1 Chrome Plated
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_XS Z1 Complete Set_Easydrain:XS-Z1 Chrome Plated:...) | Mark
3078769 | 1953 | Identity Data - Design Option: Main Model
3084041 | 2393

# IfcFlowTerminal: XS-Z1 Chrome Plated with M2 flat siphon (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_verchroomt
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: XS Z-1; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: XS-Z1 Chrome Plated with M2 flat siphon; URL: https://www.easydrain.nl/douchegoten/xs-design-z-1/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_verchroomt
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_XS Z1 Complete Set_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: XS-Z1 Chrome Plated with M2 flat siphon
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Build-in-Depth: 66 mm; Grate Length: 900 mm; Host: Level : Level 1; Tile Thickness: 5 mm
Dimensions - Do: 40 mm; Do1: 50 mm; NLRS_C_breedte: 36 mm; NLRS_C_hoogte: 66 mm; NLRS_C_lengte: 900 mm; NLRS_P_c01_diameter: 40 mm; Volume: 0.002504 m3
Identity Data - Design Option: Main Model; NLRS_C_code_product: XS-TAF 900-Z1P; NLRS_C_omschrijving: XS-Z1 - Chrome Plated Steel
Mechanical - System Classification: Sanitary
Other - Outlet angle: 90 deg; m2_vertical: no; Ref_line_angle: 180 deg; m2_flat: yes; Siphon Connection: no; standard_siphon: no; build_in_depth_calculated: 66 mm; Draingoot Depth: 24 mm; Draingoot Width: 36 mm; Family: NLRS_PF_52_UN_XS Z1 Complete Set_Easydrain: XS-Z1 Chrome Plated with M2 flat siphon; Family and Type: NLRS_PF_52_UN_XS Z1 Complete Set_Easydrain: XS-Z1 Chrome Plated with M2 flat siphon; Flange Width: 70 mm; L_/_: 17.5 mm; Leg length: 66 mm; Length_calculated: 900 mm; max_length: 1200 mm; min_length: 200 mm; Outlet_pos_length: 25 mm; Outlet_pos_width: 25 mm; Outlet depth: 44 mm; Outlet Length: 175 mm; Ro: 20 mm; Ro1: 25 mm; Siphon Depth: 66 mm; Siphon Width: 120 mm; Tile_thickness_calculated: 5 mm; Type: NLRS_PF_52_UN_XS Z1 Complete Set_Easydrain: XS-Z1 Chrome Plated with M2 flat siphon; Type Id: NLRS_PF_52_UN_XS Z1 Complete Set_Easydrain: XS-Z1 Chrome Plated with M2 flat siphon
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_XS Z1 Complete Set_Easydrain:XS-Z1 Chrome Plated with M2 flat siphon:...) | Mark
3078770 | 1954
3084042 | 2394

# IfcFlowTerminal: XS-Z1 Chrome Plated with M2 vertical outlet (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_verchroomt
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot verticale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: XS Z-1; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: XS-Z1 Chrome Plated with M2 vertical outlet; URL: https://www.easydrain.nl/douchegoten/xs-design-z-1/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_verchroomt
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_XS Z1 Complete Set_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: XS-Z1 Chrome Plated with M2 vertical outlet
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Build-in-Depth: 66 mm; Grate Length: 900 mm; Host: Level : Level 1; Tile Thickness: 5 mm
Dimensions - Do: 50 mm; Do1: 50 mm; NLRS_C_breedte: 36 mm; NLRS_C_hoogte: 66 mm; NLRS_C_lengte: 900 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.00257242 m3
Identity Data - NLRS_C_code_product: XS-TAF 900-Z1P; NLRS_C_omschrijving: XS-Z1 - Chrome Plated Steel
Mechanical - System Classification: Sanitary
Other - Outlet angle: 180 deg; m2_vertical: yes; m2_flat: no; Ref_line_angle: 180 deg; Siphon Connection: yes; standard_siphon: no; build_in_depth_calculated: 66 mm; Draingoot Depth: 24 mm; Draingoot Width: 36 mm; Family: NLRS_PF_52_UN_XS Z1 Complete Set_Easydrain: XS-Z1 Chrome Plated with M2 vertical outlet; Family and Type: NLRS_PF_52_UN_XS Z1 Complete Set_Easydrain: XS-Z1 Chrome Plated with M2 vertical outlet; Flange Width: 70 mm; L_/_: 17.5 mm; Leg length: 66 mm; Length_calculated: 900 mm; max_length: 1200 mm; min_length: 200 mm; Outlet_pos_length: 25 mm; Outlet_pos_width: 50 mm; Outlet depth: 24 mm; Outlet Length: 213 mm; Ro: 25 mm; Ro1: 25 mm; Siphon Depth: 66 mm; Siphon Width: 120 mm; Tile_thickness_calculated: 5 mm; Type: NLRS_PF_52_UN_XS Z1 Complete Set_Easydrain: XS-Z1 Chrome Plated with M2 vertical outlet; Type Id: NLRS_PF_52_UN_XS Z1 Complete Set_Easydrain: XS-Z1 Chrome Plated with M2 vertical outlet
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_XS Z1 Complete Set_Easydrain:XS-Z1 Chrome Plated with M2 vertical outlet:...) | Mark
3078771 | 1955
3084043 | 2395

# IfcFlowTerminal: XS-Z4 Brushed (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: XS Z-4; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: XS-Z4 Brushed; URL: https://www.easydrain.nl/douchegoten/xs-design-z-4/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_XS Z4 Complete Set_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: XS-Z4 Brushed
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Build-in-Depth: 66 mm; Grate Length: 900 mm; Host: Level : Level 1; Tile Thickness: 5 mm
Dimensions - Do: 50 mm; Do1: 50 mm; NLRS_C_breedte: 70 mm; NLRS_C_hoogte: 66 mm; NLRS_C_lengte: 900 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.00310062 m3
Identity Data - NLRS_C_code_product: XS-TAF 900-Z4M; NLRS_C_omschrijving: XS-Z4 - Brushed Stainless Steel
Mechanical - System Classification: Sanitary
Other - Outlet angle: 90 deg; m2_vertical: no; m2_flat: no; Ref_line_angle: 180 deg; Siphon Connection: yes; standard_siphon: yes; build_in_depth_calculated: 66 mm; Draingoot Depth: 24 mm; Draingoot Width: 70 mm; Family: NLRS_PF_52_UN_XS Z4 Complete Set_Easydrain: XS-Z4 Brushed; Family and Type: NLRS_PF_52_UN_XS Z4 Complete Set_Easydrain: XS-Z4 Brushed; Flange Width: 70 mm; L_/_: 17.5 mm; Leg length: 66 mm; Length_calculated: 900 mm; max_length: 1200 mm; min_length: 800 mm; Outlet_pos_length: 25 mm; Outlet_pos_width: 25 mm; Outlet depth: 69 mm; Outlet Length: 168 mm; Ro: 25 mm; Ro1: 25 mm; Siphon Depth: 66 mm; Siphon Width: 120 mm; Tile_thickness_calculated: 5 mm; Type: NLRS_PF_52_UN_XS Z4 Complete Set_Easydrain: XS-Z4 Brushed; Type Id: NLRS_PF_52_UN_XS Z4 Complete Set_Easydrain: XS-Z4 Brushed
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_XS Z4 Complete Set_Easydrain:XS-Z4 Brushed:...) | Mark
3083154 | 1960 | Identity Data - Design Option: Main Model
3084048 | 2400

# IfcFlowTerminal: XS-Z4 Brushed with M2 flat siphon (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: XS Z-4; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: XS-Z4 Brushed with M2 flat siphon; URL: https://www.easydrain.nl/douchegoten/xs-design-z-4/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_XS Z4 Complete Set_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: XS-Z4 Brushed with M2 flat siphon
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Build-in-Depth: 66 mm; Grate Length: 900 mm; Host: Level : Level 1; Tile Thickness: 5 mm
Dimensions - Do: 40 mm; Do1: 50 mm; NLRS_C_breedte: 70 mm; NLRS_C_hoogte: 66 mm; NLRS_C_lengte: 900 mm; NLRS_P_c01_diameter: 40 mm; Volume: 0.0030322 m3
Identity Data - NLRS_C_code_product: XS-TAF 900-Z4M; NLRS_C_omschrijving: XS-Z4 - Brushed Stainless Steel
Mechanical - System Classification: Sanitary
Other - Outlet angle: 90 deg; m2_vertical: no; Ref_line_angle: 180 deg; m2_flat: yes; Siphon Connection: no; standard_siphon: no; build_in_depth_calculated: 66 mm; Draingoot Depth: 24 mm; Draingoot Width: 70 mm; Family: NLRS_PF_52_UN_XS Z4 Complete Set_Easydrain: XS-Z4 Brushed with M2 flat siphon; Family and Type: NLRS_PF_52_UN_XS Z4 Complete Set_Easydrain: XS-Z4 Brushed with M2 flat siphon; Flange Width: 70 mm; L_/_: 17.5 mm; Leg length: 66 mm; Length_calculated: 900 mm; max_length: 1200 mm; min_length: 800 mm; Outlet_pos_length: 25 mm; Outlet_pos_width: 25 mm; Outlet depth: 44 mm; Outlet Length: 175 mm; Ro: 20 mm; Ro1: 25 mm; Siphon Depth: 66 mm; Siphon Width: 120 mm; Tile_thickness_calculated: 5 mm; Type: NLRS_PF_52_UN_XS Z4 Complete Set_Easydrain: XS-Z4 Brushed with M2 flat siphon; Type Id: NLRS_PF_52_UN_XS Z4 Complete Set_Easydrain: XS-Z4 Brushed with M2 flat siphon
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_XS Z4 Complete Set_Easydrain:XS-Z4 Brushed with M2 flat siphon:...) | Mark
3083159 | 1961 | Identity Data - Design Option: Main Model
3084049 | 2401

# IfcFlowTerminal: XS-Z4 Brushed with M2 vertical outlet (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot verticale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: XS Z-4; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: XS-Z4 Brushed with M2 vertical outlet; URL: https://www.easydrain.nl/douchegoten/xs-design-z-4/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_XS Z4 Complete Set_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: XS-Z4 Brushed with M2 vertical outlet
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Build-in-Depth: 66 mm; Grate Length: 900 mm; Host: Level : Level 1; Tile Thickness: 5 mm
Dimensions - Do: 50 mm; Do1: 50 mm; NLRS_C_breedte: 70 mm; NLRS_C_hoogte: 66 mm; NLRS_C_lengte: 900 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.00310062 m3
Identity Data - NLRS_C_code_product: XS-TAF 900-Z4M; NLRS_C_omschrijving: XS-Z4 - Brushed Stainless Steel
Mechanical - System Classification: Sanitary
Other - Outlet angle: 180 deg; m2_vertical: yes; m2_flat: no; Ref_line_angle: 180 deg; Siphon Connection: yes; standard_siphon: no; build_in_depth_calculated: 66 mm; Draingoot Depth: 24 mm; Draingoot Width: 70 mm; Family: NLRS_PF_52_UN_XS Z4 Complete Set_Easydrain: XS-Z4 Brushed with M2 vertical outlet; Family and Type: NLRS_PF_52_UN_XS Z4 Complete Set_Easydrain: XS-Z4 Brushed with M2 vertical outlet; Flange Width: 70 mm; L_/_: 17.5 mm; Leg length: 66 mm; Length_calculated: 900 mm; max_length: 1200 mm; min_length: 800 mm; Outlet_pos_length: 25 mm; Outlet_pos_width: 50 mm; Outlet depth: 24 mm; Outlet Length: 213 mm; Ro: 25 mm; Ro1: 25 mm; Siphon Depth: 66 mm; Siphon Width: 120 mm; Tile_thickness_calculated: 5 mm; Type: NLRS_PF_52_UN_XS Z4 Complete Set_Easydrain: XS-Z4 Brushed with M2 vertical outlet; Type Id: NLRS_PF_52_UN_XS Z4 Complete Set_Easydrain: XS-Z4 Brushed with M2 vertical outlet
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_XS Z4 Complete Set_Easydrain:XS-Z4 Brushed with M2 vertical outlet:...) | Mark
3083164 | 1962 | Identity Data - Design Option: Main Model
3084050 | 2402

# IfcFlowTerminal: XS-Z4 Chrome Plated (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_verchroomt
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: XS Z-4; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: XS-Z4 Chrome Plated; URL: https://www.easydrain.nl/douchegoten/xs-design-z-4/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_verchroomt
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_XS Z4 Complete Set_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: XS-Z4 Chrome Plated
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Build-in-Depth: 66 mm; Grate Length: 900 mm; Host: Level : Level 1; Tile Thickness: 5 mm
Dimensions - Do: 50 mm; Do1: 50 mm; NLRS_C_breedte: 70 mm; NLRS_C_hoogte: 66 mm; NLRS_C_lengte: 900 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.00310062 m3
Identity Data - NLRS_C_code_product: XS-TAF 900-Z4P; NLRS_C_omschrijving: XS-Z4 - Chrome Plated Steel
Mechanical - System Classification: Sanitary
Other - Outlet angle: 90 deg; m2_vertical: no; m2_flat: no; Ref_line_angle: 180 deg; Siphon Connection: yes; standard_siphon: yes; build_in_depth_calculated: 66 mm; Draingoot Depth: 24 mm; Draingoot Width: 70 mm; Family: NLRS_PF_52_UN_XS Z4 Complete Set_Easydrain: XS-Z4 Chrome Plated; Family and Type: NLRS_PF_52_UN_XS Z4 Complete Set_Easydrain: XS-Z4 Chrome Plated; Flange Width: 70 mm; L_/_: 17.5 mm; Leg length: 66 mm; Length_calculated: 900 mm; max_length: 1200 mm; min_length: 800 mm; Outlet_pos_length: 25 mm; Outlet_pos_width: 25 mm; Outlet depth: 69 mm; Outlet Length: 168 mm; Ro: 25 mm; Ro1: 25 mm; Siphon Depth: 66 mm; Siphon Width: 120 mm; Tile_thickness_calculated: 5 mm; Type: NLRS_PF_52_UN_XS Z4 Complete Set_Easydrain: XS-Z4 Chrome Plated; Type Id: NLRS_PF_52_UN_XS Z4 Complete Set_Easydrain: XS-Z4 Chrome Plated
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_XS Z4 Complete Set_Easydrain:XS-Z4 Chrome Plated:...) | Mark
3083169 | 1963 | Identity Data - Design Option: Main Model
3084051 | 2403

# IfcFlowTerminal: XS-Z4 Chrome Plated with M2 flat siphon (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_verchroomt
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: XS Z-4; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: XS-Z4 Chrome Plated with M2 flat siphon; URL: https://www.easydrain.nl/douchegoten/xs-design-z-4/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_verchroomt
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_XS Z4 Complete Set_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: XS-Z4 Chrome Plated with M2 flat siphon
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Build-in-Depth: 66 mm; Grate Length: 900 mm; Host: Level : Level 1; Tile Thickness: 5 mm
