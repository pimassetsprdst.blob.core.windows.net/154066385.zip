Properties of the parts of a building model (IFC2X3), part 4 of 9

# IfcFlowTerminal: Compact TAF (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Compact TAF; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; Type Name: Compact TAF; URL: http://www.easydrain.nl/nl/easy-drain/compact/compact-taf.html
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; materiaal_WPS: NLRS_52_WPS_ EasyDrain; NLRS_C_materiaal_01: NLRS_n1_Asfalt_bitumen
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Compact TAF_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact TAF
Constraints - Offset: 0 mm; Level: Level: Level 1; Tile: no; Zero: yes; Extension Set: yes; Grate Length: 500 mm; Host: Level : Level 1; Single Extension Set: no; Tile Thickness: 7 mm
Dimensions - NLRS_C_breedte: 62 mm; NLRS_C_lengte: 500 mm
Identity Data - NLRS_C_omschrijving: Compact TAF
Mechanical - System Classification: Sanitary
Other - Discharge Center: 250 mm; Extension Set Length: 0 mm; Family: NLRS_PF_52_UN_Compact TAF_Easydrain: Compact TAF; Family and Type: NLRS_PF_52_UN_Compact TAF_Easydrain: Compact TAF; Flange Width: 100 mm; Length Calculated: 465 mm; max_length: 2000 mm; s: 3 mm; Tile thickness calculated: 7 mm; Type: NLRS_PF_52_UN_Compact TAF_Easydrain: Compact TAF; Type Id: NLRS_PF_52_UN_Compact TAF_Easydrain: Compact TAF; Wall profile: no
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Compact TAF_Easydrain:Compact TAF:...) | Waterseal 30mm | Waterseal 50mm | NLRS_C_hoogte (mm) | NLRS_P_c01_diameter (mm) | Volume (m3) | Mark | NLRS_C_code_product | Capacity Waterseal (m3/s) | Build-in-Depth (mm) | connector_position (mm) | product_index | ro (mm)
3054630 | yes | no | 70 | 40 | 0.00185029 | 1220 | EDCOMTAF 500 -30 | 0.025 | 63 | 38 | 33 | 20
3055099 | no | yes | 90 | 50 | 0.00218678 | 1228 | EDCOMTAF 500 -50 | 0.034 | 83 | 48 | 49 | 25
3063845 | yes | no | 70 | 40 | 0.00185029 | 1559 | EDCOMTAF 500 -30 | 0.025 | 63 | 38 | 33 | 20
3063849 | no | yes | 90 | 50 | 0.00218678 | 1563 | EDCOMTAF 500 -50 | 0.034 | 83 | 48 | 49 | 25
3083258 | yes | no | 70 | 40 | 0.00185029 | 1976 | EDCOMTAF 500 -30 | 0.025 | 63 | 38 | 33 | 20
3083262 | no | yes | 90 | 50 | 0.00218678 | 1980 | EDCOMTAF 500 -50 | 0.034 | 83 | 48 | 49 | 25 | Identity Data - Design Option: Main Model
3083734 | yes | no | 70 | 40 | 0.00185029 | 2263 | EDCOMTAF 500 -30 | 0.025 | 63 | 38 | 33 | 20
3083738 | no | yes | 90 | 50 | 0.00218678 | 2267 | EDCOMTAF 500 -50 | 0.034 | 83 | 48 | 49 | 25

# IfcFlowTerminal: Compact TAF (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_n1_Asfalt_bitumen, NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Compact TAF; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; Type Name: Compact TAF; URL: http://www.easydrain.nl/nl/easy-drain/compact/compact-taf.html
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; materiaal_WPS: NLRS_52_WPS_ EasyDrain; NLRS_C_materiaal_01: NLRS_n1_Asfalt_bitumen
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Compact TAF_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact TAF
Constraints - Level: Level: Level 1; Offset: 0 mm; Tile: yes; Zero: no; Extension Set: yes; Single Extension Set: no; Grate Length: 500 mm; Host: Level : Level 1; Tile Thickness: 7 mm
Dimensions - NLRS_C_breedte: 62 mm; NLRS_C_lengte: 500 mm
Identity Data - NLRS_C_omschrijving: Compact TAF
Mechanical - System Classification: Sanitary
Other - Extension Set Length: 0 mm; Family: NLRS_PF_52_UN_Compact TAF_Easydrain: Compact TAF; Family and Type: NLRS_PF_52_UN_Compact TAF_Easydrain: Compact TAF; Type: NLRS_PF_52_UN_Compact TAF_Easydrain: Compact TAF; Type Id: NLRS_PF_52_UN_Compact TAF_Easydrain: Compact TAF; Wall profile: no; Discharge Center: 250 mm; Flange Width: 100 mm; Length Calculated: 465 mm; max_length: 2000 mm; s: 3 mm; Tile thickness calculated: 7 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Compact TAF_Easydrain:Compact TAF:...) | Waterseal 30mm | Waterseal 50mm | NLRS_C_hoogte (mm) | NLRS_P_c01_diameter (mm) | Volume (m3) | Mark | NLRS_C_code_product | Capacity Waterseal (m3/s) | Build-in-Depth (mm) | connector_position (mm) | product_index | ro (mm)
3054715 | yes | no | 70 | 40 | 0.00185206 | 1222 | EDCOMTAF 500 -30 | 0.025 | 63 | 38 | 33 | 20 | Identity Data - Design Option: Main Model
3055101 | no | yes | 90 | 50 | 0.00218856 | 1230 | EDCOMTAF 500 -50 | 0.034 | 83 | 48 | 49 | 25
3063847 | yes | no | 70 | 40 | 0.00185206 | 1561 | EDCOMTAF 500 -30 | 0.025 | 63 | 38 | 33 | 20
3063851 | no | yes | 90 | 50 | 0.00218856 | 1565 | EDCOMTAF 500 -50 | 0.034 | 83 | 48 | 49 | 25
3083260 | yes | no | 70 | 40 | 0.00185206 | 1978 | EDCOMTAF 500 -30 | 0.025 | 63 | 38 | 33 | 20 | Identity Data - Design Option: Main Model
3083264 | no | yes | 90 | 50 | 0.00218856 | 1982 | EDCOMTAF 500 -50 | 0.034 | 83 | 48 | 49 | 25
3083736 | yes | no | 70 | 40 | 0.00185206 | 2265 | EDCOMTAF 500 -30 | 0.025 | 63 | 38 | 33 | 20 | Identity Data - Design Option: Main Model
3083740 | no | yes | 90 | 50 | 0.00218856 | 2269 | EDCOMTAF 500 -50 | 0.034 | 83 | 48 | 49 | 25 | Identity Data - Design Option: Main Model

# IfcFlowTerminal: Compact TAF Low Inleg (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_n1_Asfalt_bitumen, NLRS_52_WPS_ EasyDrain, Default
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Compact TAF Modulo; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Compact TAF Low Inleg; URL: https://www.easydrain.nl/nieuws/nieuw-easy-drain-compact-taf-verlaagd/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_n1_Asfalt_bitumen
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Compact TAF Low_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact TAF Low Inleg
Constraints - Offset: 0 mm; Level: Level: Level 1; Grate Length: 700 mm; Host: Level : Level 1; Tile Thickness: 3 mm
Dimensions - NLRS_C_breedte: 62 mm; NLRS_C_lengte: 700 mm
Identity Data - NLRS_C_omschrijving: Compact TAF Low Inleg
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Tile: yes; Zero: no; Discharge Center: 350 mm; Family: NLRS_PF_52_UN_Compact TAF Low_Easydrain: Compact TAF Low Inleg; Family and Type: NLRS_PF_52_UN_Compact TAF Low_Easydrain: Compact TAF Low Inleg; Length calculated: 665 mm; max_length: 2000 mm; s: 3 mm; Tile thickness calculated: 3 mm; Type: NLRS_PF_52_UN_Compact TAF Low_Easydrain: Compact TAF Low Inleg; Type Id: NLRS_PF_52_UN_Compact TAF Low_Easydrain: Compact TAF Low Inleg
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Compact TAF Low_Easydrain:Compact TAF Low Inleg:...) | Waterseal 30mm | Waterseal 50mm | NLRS_C_hoogte (mm) | NLRS_P_c01_diameter (mm) | Volume (m3) | Mark | NLRS_C_code_product | Build-in-Depth (mm) | connector_position (mm) | product_index | ro (mm)
3063922 | yes | no | 66 | 40 | 0.00213254 | 1599 | EDM1TAFLT 700-30 | 63 | 38 | 35 | 20 | Identity Data - Design Option: Main Model
3064200 | no | yes | 86 | 50 | 0.00246903 | 1600 | EDM1TAFLT 700-50 | 83 | 48 | 51 | 25

# IfcFlowTerminal: Compact TAF Low Zero geborsteld RVS (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain, Default
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Compact TAF Modulo; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Compact TAF Low Zero geborsteld RVS; URL: https://www.easydrain.nl/nieuws/nieuw-easy-drain-compact-taf-verlaagd/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Compact TAF Low_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact TAF Low Zero geborsteld RVS
Constraints - Offset: 0 mm; Level: Level: Level 1; Grate Length: 700 mm; Host: Level : Level 1; Tile Thickness: 3 mm
Dimensions - NLRS_C_breedte: 62 mm; NLRS_C_lengte: 700 mm
Identity Data - NLRS_C_omschrijving: Compact TAF Low Zero
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Tile: no; Zero: yes; Discharge Center: 350 mm; Family: NLRS_PF_52_UN_Compact TAF Low_Easydrain: Compact TAF Low Zero geborsteld RVS; Family and Type: NLRS_PF_52_UN_Compact TAF Low_Easydrain: Compact TAF Low Zero geborsteld RVS; Length calculated: 665 mm; max_length: 2000 mm; s: 3 mm; Tile thickness calculated: 3 mm; Type: NLRS_PF_52_UN_Compact TAF Low_Easydrain: Compact TAF Low Zero geborsteld RVS; Type Id: NLRS_PF_52_UN_Compact TAF Low_Easydrain: Compact TAF Low Zero geborsteld RVS
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Compact TAF Low_Easydrain:Compact TAF Low Zero geborsteld RVS:...) | Waterseal 30mm | Waterseal 50mm | NLRS_C_hoogte (mm) | NLRS_P_c01_diameter (mm) | Volume (m3) | Mark | NLRS_C_code_product | Build-in-Depth (mm) | connector_position (mm) | product_index | ro (mm)
3064282 | yes | no | 66 | 40 | 0.00213254 | 1601 | EDM1TAFLZ 700-30 | 63 | 38 | 35 | 20
3064366 | no | yes | 86 | 50 | 0.00246903 | 1602 | EDM1TAFLZ 700-50 | 83 | 48 | 51 | 25

# IfcFlowTerminal: Compact TAF Modulo Classic (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Compact TAF Modulo; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Compact TAF Modulo Classic; URL: https://www.easydrain.nl/douchegoten/compact-taf-modulo/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Compact TAF Modulo_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact TAF Modulo Classic
Constraints - Offset: 0 mm; Level: Level: Level 1; Single Extension Set: no; Extension Set: no; Grate Length: 700 mm; Host: Level : Level 1; Tile Thickness: 7 mm
Dimensions - NLRS_C_breedte: 62 mm; NLRS_C_lengte: 700 mm
Identity Data - NLRS_C_omschrijving: Compact TAF Modulo
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Discharge Center: 350 mm; ExtensionSet_length: 17.5 mm; Family: NLRS_PF_52_UN_Compact TAF Modulo_Easydrain: Compact TAF Modulo Classic; Family and Type: NLRS_PF_52_UN_Compact TAF Modulo_Easydrain: Compact TAF Modulo Classic; Length calculated: 665 mm; max_length: 2000 mm; s: 3 mm; Tile thickness calculated: 7 mm; Type: NLRS_PF_52_UN_Compact TAF Modulo_Easydrain: Compact TAF Modulo Classic; Type Id: NLRS_PF_52_UN_Compact TAF Modulo_Easydrain: Compact TAF Modulo Classic
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Compact TAF Modulo_Easydrain:Compact TAF Modulo Classic:...) | Waterseal 30mm | Waterseal 50mm | NLRS_C_hoogte (mm) | NLRS_P_c01_diameter (mm) | Volume (m3) | Mark | NLRS_C_code_product | product_index | Build-in-Depth (mm) | connector_position (mm) | ro (mm)
3055458 | yes | no | 70 | 40 | 0.00225915 | 1240 | EDM1TAFC 700 -30 | 1 | 63 | 38 | 20
3056412 | no | yes | 90 | 50 | 0.00259565 | 1250 | EDM1TAFC 700 -50 | 16 | 83 | 48 | 25
3063861 | yes | no | 70 | 40 | 0.00225915 | 1575 | EDM1TAFC 700 -30 | 1 | 63 | 38 | 20
3063871 | no | yes | 90 | 50 | 0.00259565 | 1585 | EDM1TAFC 700 -50 | 16 | 83 | 48 | 25
3083297 | yes | no | 70 | 40 | 0.00225915 | 1992 | EDM1TAFC 700 -30 | 1 | 63 | 38 | 20
3083307 | no | yes | 90 | 50 | 0.00259565 | 2002 | EDM1TAFC 700 -50 | 16 | 83 | 48 | 25 | Identity Data - Design Option: Main Model
3083750 | yes | no | 70 | 40 | 0.00225915 | 2279 | EDM1TAFC 700 -30 | 1 | 63 | 38 | 20 | Identity Data - Design Option: Main Model
3083760 | no | yes | 90 | 50 | 0.00259565 | 2289 | EDM1TAFC 700 -50 | 16 | 83 | 48 | 25 | Identity Data - Design Option: Main Model

# IfcFlowTerminal: Compact TAF Modulo Design Z2 (6)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Compact TAF Modulo Design; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Compact TAF Modulo Design Z2; URL: https://www.easydrain.nl/design-drains/compact-taf-modulo-design/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Compact TAF Modulo Design_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact TAF Modulo Design Z2
Constraints - Level: Level: Level 1; Offset: 0 mm; Grate Length: 800 mm; Host: Level : Level 1; Tile Thickness: 7 mm
Dimensions - NLRS_C_breedte: 62 mm; NLRS_C_lengte: 800 mm
Identity Data - NLRS_C_omschrijving: Compact TAF Modulo Design Z2
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Discharge Center: 400 mm; Family: NLRS_PF_52_UN_Compact TAF Modulo Design_Easydrain: Compact TAF Modulo Design Z2; Family and Type: NLRS_PF_52_UN_Compact TAF Modulo Design_Easydrain: Compact TAF Modulo Design Z2; Length calculated: 765 mm; max_length: 1200 mm; s: 3 mm; Tile thickness calculated: 7 mm; Type: NLRS_PF_52_UN_Compact TAF Modulo Design_Easydrain: Compact TAF Modulo Design Z2; Type Id: NLRS_PF_52_UN_Compact TAF Modulo Design_Easydrain: Compact TAF Modulo Design Z2; Z2: yes; Z4: no
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Compact TAF Modulo Design_Easydrain:Compact TAF Modulo Design Z2:...) | Waterseal 30mm | Waterseal 50mm | NLRS_C_hoogte (mm) | NLRS_P_c01_diameter (mm) | Volume (m3) | Mark | NLRS_C_code_product | product_index | Build-in-Depth (mm) | connector_position (mm) | ro (mm)
3056470 | yes | no | 70 | 40 | 0.00243743 | 1260 | EDM1TAFZ2 800 -30 | 1 | 63 | 38 | 20
3056667 | no | yes | 90 | 50 | 0.00277392 | 1262 | EDM1TAFZ2 800 -50 | 9 | 83 | 48 | 25
3063881 | yes | no | 70 | 40 | 0.00243743 | 1595 | EDM1TAFZ2 800 -30 | 1 | 63 | 38 | 20
3063883 | no | yes | 90 | 50 | 0.00277392 | 1597 | EDM1TAFZ2 800 -50 | 9 | 83 | 48 | 25 | Identity Data - Design Option: Main Model
3083770 | yes | no | 70 | 40 | 0.00243743 | 2299 | EDM1TAFZ2 800 -30 | 1 | 63 | 38 | 20
3083772 | no | yes | 90 | 50 | 0.00277392 | 2301 | EDM1TAFZ2 800 -50 | 9 | 83 | 48 | 25 | Identity Data - Design Option: Main Model

# IfcFlowTerminal: Compact TAF Modulo Design Z4 (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Compact TAF Modulo Design; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Compact TAF Modulo Design Z4; URL: https://www.easydrain.nl/design-drains/compact-taf-modulo-design/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Compact TAF Modulo Design_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact TAF Modulo Design Z4
Constraints - Offset: 0 mm; Level: Level: Level 1; Grate Length: 800 mm; Host: Level : Level 1; Tile Thickness: 7 mm
Dimensions - NLRS_C_breedte: 62 mm; NLRS_C_lengte: 800 mm
Identity Data - NLRS_C_omschrijving: Compact TAF Modulo Design Z4
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Discharge Center: 400 mm; Family: NLRS_PF_52_UN_Compact TAF Modulo Design_Easydrain: Compact TAF Modulo Design Z4; Family and Type: NLRS_PF_52_UN_Compact TAF Modulo Design_Easydrain: Compact TAF Modulo Design Z4; Length calculated: 765 mm; max_length: 1200 mm; s: 3 mm; Tile thickness calculated: 7 mm; Type: NLRS_PF_52_UN_Compact TAF Modulo Design_Easydrain: Compact TAF Modulo Design Z4; Type Id: NLRS_PF_52_UN_Compact TAF Modulo Design_Easydrain: Compact TAF Modulo Design Z4; Z2: no; Z4: yes
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Compact TAF Modulo Design_Easydrain:Compact TAF Modulo Design Z4:...) | Waterseal 30mm | Waterseal 50mm | NLRS_C_hoogte (mm) | NLRS_P_c01_diameter (mm) | Volume (m3) | Design Option | Mark | NLRS_C_code_product | Build-in-Depth (mm) | connector_position (mm) | product_index | ro (mm)
3056586 | yes | no | 70 | 40 | 0.00249823 | Main Model | 1261 | EDM1TAFZ4 800 -30 | 63 | 38 | 5 | 20
3056668 | no | yes | 90 | 50 | 0.00283472 | Main Model | 1263 | EDM1TAFZ4 800 -50 | 83 | 48 | 13 | 25
3063882 | yes | no | 70 | 40 | 0.00249823 |  | 1596 | EDM1TAFZ4 800 -30 | 63 | 38 | 5 | 20
3063884 | no | yes | 90 | 50 | 0.00283472 | Main Model | 1598 | EDM1TAFZ4 800 -50 | 83 | 48 | 13 | 25
3083771 | yes | no | 70 | 40 | 0.00249823 |  | 2300 | EDM1TAFZ4 800 -30 | 63 | 38 | 5 | 20
3083773 | no | yes | 90 | 50 | 0.00283472 | Main Model | 2302 | EDM1TAFZ4 800 -50 | 83 | 48 | 13 | 25
3084323 | yes | no | 70 | 40 | 0.00249823 | Main Model | 2460 | EDM1TAFZ4 800 -30 | 63 | 38 | 5 | 20
3084465 | no | yes | 90 | 50 | 0.00283472 | Main Model | 2461 | EDM1TAFZ4 800 -50 | 83 | 48 | 13 | 25

# IfcFlowTerminal: Compact TAF Modulo Glas wit glans (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: Glass, Cast, White, NLRS_52_WPS_ EasyDrain, NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Compact TAF Modulo; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Compact TAF Modulo Glas wit glans; URL: https://www.easydrain.nl/douchegoten/compact-taf-modulo/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Compact TAF Modulo_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact TAF Modulo Glas wit glans
Constraints - Offset: 0 mm; Level: Level: Level 1; Single Extension Set: no; Extension Set: no; Grate Length: 700 mm; Host: Level : Level 1; Tile Thickness: 7 mm
Dimensions - NLRS_C_breedte: 62 mm; NLRS_C_lengte: 700 mm
Identity Data - NLRS_C_omschrijving: Compact TAF Modulo
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Discharge Center: 350 mm; ExtensionSet_length: 17.5 mm; Family: NLRS_PF_52_UN_Compact TAF Modulo_Easydrain: Compact TAF Modulo Glas wit glans; Family and Type: NLRS_PF_52_UN_Compact TAF Modulo_Easydrain: Compact TAF Modulo Glas wit glans; Length calculated: 665 mm; max_length: 2000 mm; s: 3 mm; Tile thickness calculated: 7 mm; Type: NLRS_PF_52_UN_Compact TAF Modulo_Easydrain: Compact TAF Modulo Glas wit glans; Type Id: NLRS_PF_52_UN_Compact TAF Modulo_Easydrain: Compact TAF Modulo Glas wit glans
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Compact TAF Modulo_Easydrain:Compact TAF Modulo Glas wit glans:...) | Waterseal 30mm | Waterseal 50mm | NLRS_C_hoogte (mm) | NLRS_P_c01_diameter (mm) | Volume (m3) | Mark | NLRS_C_code_product | Build-in-Depth (mm) | connector_position (mm) | product_index | ro (mm) | Design Option
3055766 | yes | no | 70 | 40 | 0.0022617 | 1242 | EDM1TAFGW 700 -30 | 63 | 38 | 13 | 20
3056414 | no | yes | 90 | 50 | 0.00259819 | 1252 | EDM1TAFGW 700 -50 | 83 | 48 | 28 | 25
3063863 | yes | no | 70 | 40 | 0.0022617 | 1577 | EDM1TAFGW 700 -30 | 63 | 38 | 13 | 20 | Main Model
3063873 | no | yes | 90 | 50 | 0.00259819 | 1587 | EDM1TAFGW 700 -50 | 83 | 48 | 28 | 25 | Main Model
3083299 | yes | no | 70 | 40 | 0.0022617 | 1994 | EDM1TAFGW 700 -30 | 63 | 38 | 13 | 20 | Main Model
3083309 | no | yes | 90 | 50 | 0.00259819 | 2004 | EDM1TAFGW 700 -50 | 83 | 48 | 28 | 25 | Main Model
3083752 | yes | no | 70 | 40 | 0.0022617 | 2281 | EDM1TAFGW 700 -30 | 63 | 38 | 13 | 20 | Main Model
3083762 | no | yes | 90 | 50 | 0.00259819 | 2291 | EDM1TAFGW 700 -50 | 83 | 48 | 28 | 25 | Main Model

# IfcFlowTerminal: Compact TAF Modulo Glas zwart glans (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: Glass, Cast, Gray, NLRS_52_WPS_ EasyDrain, NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Compact TAF Modulo; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Compact TAF Modulo Glas zwart glans; URL: https://www.easydrain.nl/douchegoten/compact-taf-modulo/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Compact TAF Modulo_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact TAF Modulo Glas zwart glans
Constraints - Offset: 0 mm; Level: Level: Level 1; Single Extension Set: no; Extension Set: no; Grate Length: 700 mm; Host: Level : Level 1; Tile Thickness: 7 mm
Dimensions - NLRS_C_breedte: 62 mm; NLRS_C_lengte: 700 mm
Identity Data - NLRS_C_omschrijving: Compact TAF Modulo
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Discharge Center: 350 mm; ExtensionSet_length: 17.5 mm; Family: NLRS_PF_52_UN_Compact TAF Modulo_Easydrain: Compact TAF Modulo Glas zwart glans; Family and Type: NLRS_PF_52_UN_Compact TAF Modulo_Easydrain: Compact TAF Modulo Glas zwart glans; Length calculated: 665 mm; max_length: 2000 mm; s: 3 mm; Tile thickness calculated: 7 mm; Type: NLRS_PF_52_UN_Compact TAF Modulo_Easydrain: Compact TAF Modulo Glas zwart glans; Type Id: NLRS_PF_52_UN_Compact TAF Modulo_Easydrain: Compact TAF Modulo Glas zwart glans
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Compact TAF Modulo_Easydrain:Compact TAF Modulo Glas zwart glans:...) | Waterseal 30mm | Waterseal 50mm | NLRS_C_hoogte (mm) | NLRS_P_c01_diameter (mm) | Volume (m3) | Mark | NLRS_C_code_product | Build-in-Depth (mm) | connector_position (mm) | product_index | ro (mm)
3055933 | yes | no | 70 | 40 | 0.0022617 | 1244 | EDM1TAFGS 700 -30 | 63 | 38 | 10 | 20
3056416 | no | yes | 90 | 50 | 0.00259819 | 1254 | EDM1TAFGS 700 -50 | 83 | 48 | 25 | 25 | Identity Data - Design Option: Main Model
3063865 | yes | no | 70 | 40 | 0.0022617 | 1579 | EDM1TAFGS 700 -30 | 63 | 38 | 10 | 20
3063875 | no | yes | 90 | 50 | 0.00259819 | 1589 | EDM1TAFGS 700 -50 | 83 | 48 | 25 | 25
3083301 | yes | no | 70 | 40 | 0.0022617 | 1996 | EDM1TAFGS 700 -30 | 63 | 38 | 10 | 20
3083311 | no | yes | 90 | 50 | 0.00259819 | 2006 | EDM1TAFGS 700 -50 | 83 | 48 | 25 | 25
3083754 | yes | no | 70 | 40 | 0.0022617 | 2283 | EDM1TAFGS 700 -30 | 63 | 38 | 10 | 20
3083764 | no | yes | 90 | 50 | 0.00259819 | 2293 | EDM1TAFGS 700 -50 | 83 | 48 | 25 | 25 | Identity Data - Design Option: Main Model

# IfcFlowTerminal: Compact TAF Modulo Zero+ geborsteld RVS (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Compact TAF Modulo; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Compact TAF Modulo Zero+ geborsteld RVS; URL: https://www.easydrain.nl/douchegoten/compact-taf-modulo/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Compact TAF Modulo_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact TAF Modulo Zero+ geborsteld RVS
Constraints - Level: Level: Level 1; Offset: 0 mm; Single Extension Set: no; Extension Set: no; Grate Length: 700 mm; Host: Level : Level 1; Tile Thickness: 7 mm
Dimensions - NLRS_C_breedte: 62 mm; NLRS_C_lengte: 700 mm
Identity Data - NLRS_C_omschrijving: Compact TAF Modulo
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Discharge Center: 350 mm; ExtensionSet_length: 17.5 mm; Family: NLRS_PF_52_UN_Compact TAF Modulo_Easydrain: Compact TAF Modulo Zero+ geborsteld RVS; Family and Type: NLRS_PF_52_UN_Compact TAF Modulo_Easydrain: Compact TAF Modulo Zero+ geborsteld RVS; Length calculated: 665 mm; max_length: 2000 mm; s: 3 mm; Tile thickness calculated: 7 mm; Type: NLRS_PF_52_UN_Compact TAF Modulo_Easydrain: Compact TAF Modulo Zero+ geborsteld RVS; Type Id: NLRS_PF_52_UN_Compact TAF Modulo_Easydrain: Compact TAF Modulo Zero+ geborsteld RVS
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Compact TAF Modulo_Easydrain:Compact TAF Modulo Zero+ geborsteld RVS:...) | Waterseal 30mm | Waterseal 50mm | NLRS_C_hoogte (mm) | NLRS_P_c01_diameter (mm) | Volume (m3) | Mark | NLRS_C_code_product | Build-in-Depth (mm) | connector_position (mm) | product_index | ro (mm)
3056106 | yes | no | 70 | 40 | 0.00225915 | 1246 | EDM1TAFZM 700 -30 | 63 | 38 | 4 | 20
3056418 | no | yes | 90 | 50 | 0.00259565 | 1256 | EDM1TAFZM 700 -50 | 83 | 48 | 19 | 25
3063867 | yes | no | 70 | 40 | 0.00225915 | 1581 | EDM1TAFZM 700 -30 | 63 | 38 | 4 | 20
3063877 | no | yes | 90 | 50 | 0.00259565 | 1591 | EDM1TAFZM 700 -50 | 83 | 48 | 19 | 25
3083303 | yes | no | 70 | 40 | 0.00225915 | 1998 | EDM1TAFZM 700 -30 | 63 | 38 | 4 | 20
3083313 | no | yes | 90 | 50 | 0.00259565 | 2008 | EDM1TAFZM 700 -50 | 83 | 48 | 19 | 25
3083756 | yes | no | 70 | 40 | 0.00225915 | 2285 | EDM1TAFZM 700 -30 | 63 | 38 | 4 | 20 | Identity Data - Design Option: Main Model
3083766 | no | yes | 90 | 50 | 0.00259565 | 2295 | EDM1TAFZM 700 -50 | 83 | 48 | 19 | 25

# IfcFlowTerminal: Compact TAF Modulo Zero+ verchroomd RVS (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_gepolijst, NLRS_52_WPS_ EasyDrain, NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Compact TAF Modulo; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Compact TAF Modulo Zero+ verchroomd RVS; URL: https://www.easydrain.nl/douchegoten/compact-taf-modulo/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Compact TAF Modulo_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact TAF Modulo Zero+ verchroomd RVS
Constraints - Level: Level: Level 1; Offset: 0 mm; Single Extension Set: no; Extension Set: no; Grate Length: 700 mm; Host: Level : Level 1; Tile Thickness: 7 mm
Dimensions - NLRS_C_breedte: 62 mm; NLRS_C_lengte: 700 mm
Identity Data - NLRS_C_omschrijving: Compact TAF Modulo
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Discharge Center: 350 mm; ExtensionSet_length: 17.5 mm; Family: NLRS_PF_52_UN_Compact TAF Modulo_Easydrain: Compact TAF Modulo Zero+ verchroomd RVS; Family and Type: NLRS_PF_52_UN_Compact TAF Modulo_Easydrain: Compact TAF Modulo Zero+ verchroomd RVS; Length calculated: 665 mm; max_length: 2000 mm; s: 3 mm; Tile thickness calculated: 7 mm; Type: NLRS_PF_52_UN_Compact TAF Modulo_Easydrain: Compact TAF Modulo Zero+ verchroomd RVS; Type Id: NLRS_PF_52_UN_Compact TAF Modulo_Easydrain: Compact TAF Modulo Zero+ verchroomd RVS
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Compact TAF Modulo_Easydrain:Compact TAF Modulo Zero+ verchroomd RVS:...) | Waterseal 30mm | Waterseal 50mm | NLRS_C_hoogte (mm) | NLRS_P_c01_diameter (mm) | Volume (m3) | Mark | NLRS_C_code_product | Build-in-Depth (mm) | connector_position (mm) | product_index | ro (mm)
3056276 | yes | no | 70 | 40 | 0.00225915 | 1248 | EDM1TAFZP 700 -30 | 63 | 38 | 7 | 20
3056420 | no | yes | 90 | 50 | 0.00259565 | 1258 | EDM1TAFZP 700 -50 | 83 | 48 | 22 | 25
3063869 | yes | no | 70 | 40 | 0.00225915 | 1583 | EDM1TAFZP 700 -30 | 63 | 38 | 7 | 20 | Identity Data - Design Option: Main Model
3063879 | no | yes | 90 | 50 | 0.00259565 | 1593 | EDM1TAFZP 700 -50 | 83 | 48 | 22 | 25 | Identity Data - Design Option: Main Model
3083305 | yes | no | 70 | 40 | 0.00225915 | 2000 | EDM1TAFZP 700 -30 | 63 | 38 | 7 | 20
3083315 | no | yes | 90 | 50 | 0.00259565 | 2010 | EDM1TAFZP 700 -50 | 83 | 48 | 22 | 25
3083758 | yes | no | 70 | 40 | 0.00225915 | 2287 | EDM1TAFZP 700 -30 | 63 | 38 | 7 | 20 | Identity Data - Design Option: Main Model
3083768 | no | yes | 90 | 50 | 0.00259565 | 2297 | EDM1TAFZP 700 -50 | 83 | 48 | 22 | 25

# IfcFlowTerminal: Compact TAF Wall (10)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Compact TAF Wall; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; Type Name: Compact TAF Wall; URL: http://www.easydrain.nl/nl/easy-drain/compact/compact-taf-wall.html
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; materiaal_WPS: NLRS_52_WPS_ EasyDrain; NLRS_C_materiaal_01: NLRS_n1_Asfalt_bitumen
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Compact TAF_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact TAF Wall
Constraints - Level: Level: Level 1; Offset: 0 mm; Tile: no; Zero: yes; Extension Set: yes; Single Extension Set: no; Grate Length: 500 mm; Host: Level : Level 1; Tile Thickness: 7 mm
Dimensions - NLRS_C_breedte: 84 mm; NLRS_C_lengte: 500 mm
Identity Data - NLRS_C_omschrijving: Compact TAF Wall
Mechanical - System Classification: Sanitary
Other - Extension Set Length: 0 mm; Discharge Center: 250 mm; Family: NLRS_PF_52_UN_Compact TAF_Easydrain: Compact TAF Wall; Family and Type: NLRS_PF_52_UN_Compact TAF_Easydrain: Compact TAF Wall; Flange Width: 100 mm; Length Calculated: 465 mm; max_length: 2000 mm; s: 3 mm; Tile thickness calculated: 7 mm; Type: NLRS_PF_52_UN_Compact TAF_Easydrain: Compact TAF Wall; Type Id: NLRS_PF_52_UN_Compact TAF_Easydrain: Compact TAF Wall; Wall profile: yes
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Compact TAF_Easydrain:Compact TAF Wall:...) | Waterseal 30mm | Waterseal 50mm | NLRS_C_hoogte (mm) | NLRS_P_c01_diameter (mm) | Volume (m3) | Mark | NLRS_C_code_product | Capacity Waterseal (m3/s) | product_index | Build-in-Depth (mm) | connector_position (mm) | ro (mm)
3055272 | yes | no | 70 | 40 | 0.00187075 | 1232 | EDCOMTAFW 500 -30 | 0.025 | 1 | 63 | 38 | 20 | Identity Data - Design Option: Main Model
3055276 | no | yes | 90 | 50 | 0.00220724 | 1236 | EDCOMTAFW 500 -50 | 0.034 | 17 | 83 | 48 | 25
3063853 | yes | no | 70 | 40 | 0.00187075 | 1567 | EDCOMTAFW 500 -30 | 0.025 | 1 | 63 | 38 | 20 | Identity Data - Design Option: Main Model
3063857 | no | yes | 90 | 50 | 0.00220724 | 1571 | EDCOMTAFW 500 -50 | 0.034 | 17 | 83 | 48 | 25 | Identity Data - Design Option: Main Model
3083266 | yes | no | 70 | 40 | 0.00187075 | 1984 | EDCOMTAFW 500 -30 | 0.025 | 1 | 63 | 38 | 20
3083270 | no | yes | 90 | 50 | 0.00220724 | 1988 | EDCOMTAFW 500 -50 | 0.034 | 17 | 83 | 48 | 25
3083742 | yes | no | 70 | 40 | 0.00187075 | 2271 | EDCOMTAFW 500 -30 | 0.025 | 1 | 63 | 38 | 20
3083746 | no | yes | 90 | 50 | 0.00220724 | 2275 | EDCOMTAFW 500 -50 | 0.034 | 17 | 83 | 48 | 25
3084257 | yes | no | 70 | 40 | 0.00187075 | 2452 | EDCOMTAFW 500 -30 | 0.025 | 1 | 63 | 38 | 20 | Identity Data - Design Option: Main Model
3084261 | no | yes | 90 | 50 | 0.00220724 | 2456 | EDCOMTAFW 500 -50 | 0.034 | 17 | 83 | 48 | 25

# IfcFlowTerminal: Compact TAF Wall (10)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_n1_Asfalt_bitumen, NLRS_h2_RVS_geborsteld, NLRS_52_WPS_ EasyDrain
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Compact TAF Wall; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; Type Name: Compact TAF Wall; URL: http://www.easydrain.nl/nl/easy-drain/compact/compact-taf-wall.html
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; materiaal_WPS: NLRS_52_WPS_ EasyDrain; NLRS_C_materiaal_01: NLRS_n1_Asfalt_bitumen
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Compact TAF_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact TAF Wall
Constraints - Offset: 0 mm; Tile: yes; Level: Level: Level 1; Zero: no; Extension Set: yes; Single Extension Set: no; Grate Length: 500 mm; Host: Level : Level 1; Tile Thickness: 7 mm
Dimensions - NLRS_C_breedte: 84 mm; NLRS_C_lengte: 500 mm
Identity Data - NLRS_C_omschrijving: Compact TAF Wall
Mechanical - System Classification: Sanitary
Other - Extension Set Length: 0 mm; Family: NLRS_PF_52_UN_Compact TAF_Easydrain: Compact TAF Wall; Family and Type: NLRS_PF_52_UN_Compact TAF_Easydrain: Compact TAF Wall; Type: NLRS_PF_52_UN_Compact TAF_Easydrain: Compact TAF Wall; Type Id: NLRS_PF_52_UN_Compact TAF_Easydrain: Compact TAF Wall; Wall profile: yes; Discharge Center: 250 mm; Flange Width: 100 mm; Length Calculated: 465 mm; max_length: 2000 mm; s: 3 mm; Tile thickness calculated: 7 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Compact TAF_Easydrain:Compact TAF Wall:...) | Waterseal 30mm | Waterseal 50mm | NLRS_C_hoogte (mm) | NLRS_P_c01_diameter (mm) | Volume (m3) | Mark | NLRS_C_code_product | Capacity Waterseal (m3/s) | product_index | Build-in-Depth (mm) | connector_position (mm) | ro (mm)
3055274 | yes | no | 70 | 40 | 0.00187252 | 1234 | EDCOMTAFW 500 -30 | 0.025 | 1 | 63 | 38 | 20
3055278 | no | yes | 90 | 50 | 0.00220902 | 1238 | EDCOMTAFW 500 -50 | 0.034 | 17 | 83 | 48 | 25 | Identity Data - Design Option: Main Model
3063855 | yes | no | 70 | 40 | 0.00187252 | 1569 | EDCOMTAFW 500 -30 | 0.025 | 1 | 63 | 38 | 20 | Identity Data - Design Option: Main Model
3063859 | no | yes | 90 | 50 | 0.00220902 | 1573 | EDCOMTAFW 500 -50 | 0.034 | 17 | 83 | 48 | 25 | Identity Data - Design Option: Main Model
3083268 | yes | no | 70 | 40 | 0.00187252 | 1986 | EDCOMTAFW 500 -30 | 0.025 | 1 | 63 | 38 | 20 | Identity Data - Design Option: Main Model
3083272 | no | yes | 90 | 50 | 0.00220902 | 1990 | EDCOMTAFW 500 -50 | 0.034 | 17 | 83 | 48 | 25 | Identity Data - Design Option: Main Model
3083744 | yes | no | 70 | 40 | 0.00187252 | 2273 | EDCOMTAFW 500 -30 | 0.025 | 1 | 63 | 38 | 20
3083748 | no | yes | 90 | 50 | 0.00220902 | 2277 | EDCOMTAFW 500 -50 | 0.034 | 17 | 83 | 48 | 25
3084259 | yes | no | 70 | 40 | 0.00187252 | 2454 | EDCOMTAFW 500 -30 | 0.025 | 1 | 63 | 38 | 20
3084263 | no | yes | 90 | 50 | 0.00220902 | 2458 | EDCOMTAFW 500 -50 | 0.034 | 17 | 83 | 48 | 25

# IfcFlowTerminal: Compact Tile (6)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_n1_Asfalt_bitumen, NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Compact Tile; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Compact Tile; URL: https://www.easydrain.nl/douchegoten/compact-ff/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: NLRS_n1_Asfalt_bitumen
Type - Other - Category: Plumbing Fixtures; WPS seal: no; Family Name: NLRS_PF_52_UN_Compact Tile_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact Tile
Constraints - Level: Level: Level 1; Offset: 0 mm; Grate Length: 500 mm; Host: Level : Level 1
Dimensions - NLRS_C_breedte: 60 mm; NLRS_C_lengte: 500 mm
Identity Data - NLRS_C_omschrijving: Compact Tile
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Family: NLRS_PF_52_UN_Compact Tile_Easydrain: Compact Tile; Family and Type: NLRS_PF_52_UN_Compact Tile_Easydrain: Compact Tile; Flange Width: 100 mm; Length Calculated: 500 mm; max_length: 1200 mm; s: 3 mm; Type: NLRS_PF_52_UN_Compact Tile_Easydrain: Compact Tile; Type Id: NLRS_PF_52_UN_Compact Tile_Easydrain: Compact Tile
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Compact Tile_Easydrain:Compact Tile:...) | Waterseal 30mm | Waterseal 50mm = Adjustable Legs | NLRS_C_hoogte (mm) | NLRS_P_c01_diameter (mm) | Volume (m3) | Mark | NLRS_C_code_product | product_index | Build-in-Depth (mm) | connector_position (mm) | ro (mm)
3083357 | yes | no | 83 | 40 | 0.00148683 | 2020 | EDCOMT 500 -30 | 1 | 73 | 38 | 20 | Identity Data - Design Option: Main Model
3083358 | no | yes | 103 | 50 | 0.00197959 | 2021 | EDCOMT 500 -50 | 9 | 93 | 48 | 25
3961704 | yes | no | 83 | 40 | 0.00148683 | 2682 | EDCOMT 500 -30 | 1 | 73 | 38 | 20
3961705 | no | yes | 103 | 50 | 0.00197959 | 2683 | EDCOMT 500 -50 | 9 | 93 | 48 | 25
3961739 | yes | no | 83 | 40 | 0.00148683 | 2694 | EDCOMT 500 -30 | 1 | 73 | 38 | 20
3961740 | no | yes | 103 | 50 | 0.00197959 | 2695 | EDCOMT 500 -50 | 9 | 93 | 48 | 25 | Identity Data - Design Option: Main Model

# IfcFlowTerminal: Compact Wall (14)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Compact; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Compact Wall; URL: https://www.easydrain.nl/douchegoten/compact-taf-wall/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Wall profile: yes; Flange: no; WPS seal: no; Family Name: NLRS_PF_52_UN_Compact_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Compact Wall
Constraints - Level: Level: Level 1; Offset: 0 mm; Grate Length: 700 mm; Host: Level : Level 1
Dimensions - NLRS_C_breedte: 74.5 mm; NLRS_C_lengte: 700 mm
Identity Data - NLRS_C_omschrijving: Compact Wall
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Family: NLRS_PF_52_UN_Compact_Easydrain: Compact Wall; Family and Type: NLRS_PF_52_UN_Compact_Easydrain: Compact Wall; Flange width: 100 mm; Length Calculated: 700 mm; max_length: 1200 mm; min_length: 700 mm; s: 1 mm; Type: NLRS_PF_52_UN_Compact_Easydrain: Compact Wall; Type Id: NLRS_PF_52_UN_Compact_Easydrain: Compact Wall
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Compact_Easydrain:Compact Wall:...) | Zero = Closed cover | Waterseal 30mm | Waterseal 50mm = Adjustable Legs | Classic | NLRS_C_hoogte (mm) = Build-in-Depth (mm) | NLRS_P_c01_diameter (mm) | Volume (m3) | Mark | NLRS_C_code_product | connector_position (mm) | product_index | ro (mm)
3083359 | no | yes | no | yes | 61 | 40 | 0.00145606 | 2022 | EDCOMW 700 -30 | 38 | 89 | 20 | Identity Data - Design Option: Main Model
3083360 | yes | yes | no | no | 61 | 40 | 0.00141418 | 2023 | EDCOMWZ 700 -30 | 38 | 95 | 20
3083361 | no | no | yes | yes | 81 | 50 | 0.00191871 | 2024 | EDCOMW 700 -50 | 48 | 101 | 25 | Identity Data - Design Option: Main Model
3083362 | yes | no | yes | no | 81 | 50 | 0.00187683 | 2025 | EDCOMWZ 700 -50 | 48 | 107 | 25
3085505 | no | yes | no | yes | 61 | 40 | 0.00145606 | 2485 | EDCOMW 700 -30 | 38 | 89 | 20
3085612 | yes | no | yes | no | 81 | 50 | 0.00187683 | 2486 | EDCOMWZ 700 -50 | 48 | 107 | 25 | Identity Data - Design Option: Main Model
3961706 | no | yes | no | yes | 61 | 40 | 0.00145606 | 2684 | EDCOMW 700 -30 | 38 | 89 | 20
3961707 | yes | yes | no | no | 61 | 40 | 0.00141418 | 2685 | EDCOMWZ 700 -30 | 38 | 95 | 20
3961708 | no | no | yes | yes | 81 | 50 | 0.00191871 | 2686 | EDCOMW 700 -50 | 48 | 101 | 25
3961709 | yes | no | yes | no | 81 | 50 | 0.00187683 | 2687 | EDCOMWZ 700 -50 | 48 | 107 | 25 | Identity Data - Design Option: Main Model
3961741 | no | yes | no | yes | 61 | 40 | 0.00145606 | 2696 | EDCOMW 700 -30 | 38 | 89 | 20
3961742 | yes | yes | no | no | 61 | 40 | 0.00141418 | 2697 | EDCOMWZ 700 -30 | 38 | 95 | 20
3961743 | no | no | yes | yes | 81 | 50 | 0.00191871 | 2698 | EDCOMW 700 -50 | 48 | 101 | 25 | Identity Data - Design Option: Main Model
3961744 | yes | no | yes | no | 81 | 50 | 0.00187683 | 2699 | EDCOMWZ 700 -50 | 48 | 107 | 25 | Identity Data - Design Option: Main Model

# IfcFlowTerminal: Dot Onderuitloop 50 mm, NLRS_PF_52_UN_Showerboard DOT_uitloop_Easydrain:Dot Onderuitloop 50 mm:3372371
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, Default
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot verticale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Dot; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Dot Onderuitloop 50 mm; URL: http://www.easydrain.nl/doucheputten/dot/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Showerboard DOT_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Dot Onderuitloop 50 mm
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Bottom Plate: yes; Build-in-Depth: 80 mm; Host: Level : Level 1; Tile Thickness: 9 mm
Dimensions - Do: 102 mm; Do1: 50 mm; NLRS_C_hoogte: 90 mm; NLRS_C_lengte: 1200 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.119095 m3
Identity Data - Design Option: Main Model; Mark: 2542; NLRS_C_code_product: EDDOT-RD; NLRS_C_omschrijving: Shower Board DOT
Mechanical - System Classification: Sanitary
Other - E: 0 mm; Board height: 40 mm; discharge_void_length: 50 mm; Family: NLRS_PF_52_UN_Showerboard DOT_uitloop_Easydrain: Dot Onderuitloop 50 mm; Family and Type: NLRS_PF_52_UN_Showerboard DOT_uitloop_Easydrain: Dot Onderuitloop 50 mm; H_Siphon: 90 mm; offset outlet: 99 mm; offset siphon: -9 mm; Outlet Depth: 90 mm; Outlet Length: 550 mm; Outlet Width: 550 mm; Showerboard baseheight: 31 mm; Showerboard Height: 50 mm; Showerboard Length: 1200 mm; Showerboard Width: 1100 mm; siphon_angle: 180 deg; Siphon_outlet_length: 40 mm; Siphon Depth: 121 mm; Siphon Height: 90 mm; Siphon offset: -31 mm; Tile_thickness_check: 9 mm; Tile Diameter: 658 mm; Type: NLRS_PF_52_UN_Showerboard DOT_uitloop_Easydrain: Dot Onderuitloop 50 mm; Type Id: NLRS_PF_52_UN_Showerboard DOT_uitloop_Easydrain: Dot Onderuitloop 50 mm; Void Diameter: 676 mm; Waterseal: 35 mm
Phasing - Phase Created: New Construction

# IfcFlowTerminal: Dot Zijuitloop hoog 50 mm, NLRS_PF_52_UN_Showerboard DOT_uitloop_Easydrain:Dot Zijuitloop hoog 50 mm:3372299
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, Default
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Dot; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Dot Zijuitloop hoog 50 mm; URL: http://www.easydrain.nl/doucheputten/dot/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Showerboard DOT_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Dot Zijuitloop hoog 50 mm
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Bottom Plate: yes; Build-in-Depth: 80 mm; Host: Level : Level 1; Tile Thickness: 9 mm
Dimensions - Do: 102 mm; Do1: 50 mm; NLRS_C_hoogte: 90 mm; NLRS_C_lengte: 1200 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.117845 m3
Identity Data - Design Option: Main Model; Mark: 2540; NLRS_C_code_product: EDDOT-RD; NLRS_C_omschrijving: Shower Board DOT
Mechanical - System Classification: Sanitary
Other - siphon_angle: 90 deg; Board height: 40 mm; discharge_void_length: 1500 mm; E: 54 mm; Family: NLRS_PF_52_UN_Showerboard DOT_uitloop_Easydrain: Dot Zijuitloop hoog 50 mm; Family and Type: NLRS_PF_52_UN_Showerboard DOT_uitloop_Easydrain: Dot Zijuitloop hoog 50 mm; H_Siphon: 90 mm; offset outlet: 45 mm; offset siphon: -9 mm; Outlet Depth: 36 mm; Outlet Length: 550 mm; Outlet Width: 550 mm; Showerboard baseheight: 31 mm; Showerboard Height: 50 mm; Showerboard Length: 1200 mm; Showerboard Width: 1100 mm; Siphon_outlet_length: 91 mm; Siphon Depth: 121 mm; Siphon Height: 90 mm; Siphon offset: -31 mm; Tile_thickness_check: 9 mm; Tile Diameter: 658 mm; Type: NLRS_PF_52_UN_Showerboard DOT_uitloop_Easydrain: Dot Zijuitloop hoog 50 mm; Type Id: NLRS_PF_52_UN_Showerboard DOT_uitloop_Easydrain: Dot Zijuitloop hoog 50 mm; Void Diameter: 676 mm; Waterseal: 50 mm
Phasing - Phase Created: New Construction

# IfcFlowTerminal: Dot Zijuitloop laag 40 mm, NLRS_PF_52_UN_Showerboard DOT_uitloop_Easydrain:Dot Zijuitloop laag 40 mm:3372089
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, Default
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Dot; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Dot Zijuitloop laag 40 mm; URL: http://www.easydrain.nl/doucheputten/dot/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Showerboard DOT_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Dot Zijuitloop laag 40 mm
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Bottom Plate: yes; Build-in-Depth: 80 mm; Host: Level : Level 1; Tile Thickness: 9 mm
Dimensions - Do: 102 mm; Do1: 40 mm; NLRS_C_hoogte: 90 mm; NLRS_C_lengte: 1200 mm; NLRS_P_c01_diameter: 40 mm; Volume: 0.11812 m3
Identity Data - Mark: 2536; NLRS_C_code_product: EDDOT-RD; NLRS_C_omschrijving: Shower Board DOT
Mechanical - System Classification: Sanitary
Other - Board height: 40 mm; discharge_void_length: 1500 mm; E: 20 mm; Family: NLRS_PF_52_UN_Showerboard DOT_uitloop_Easydrain: Dot Zijuitloop laag 40 mm; Family and Type: NLRS_PF_52_UN_Showerboard DOT_uitloop_Easydrain: Dot Zijuitloop laag 40 mm; H_Siphon: 54 mm; offset outlet: 69 mm; offset siphon: -9 mm; Outlet Depth: 60 mm; Outlet Length: 550 mm; Outlet Width: 550 mm; Showerboard baseheight: 31 mm; Showerboard Height: 50 mm; Showerboard Length: 1200 mm; Showerboard Width: 1100 mm; siphon_angle: 90 deg; Siphon_outlet_length: 91 mm; Siphon Depth: 111 mm; Siphon Height: 80 mm; Siphon offset: -31 mm; Tile_thickness_check: 9 mm; Tile Diameter: 658 mm; Type: NLRS_PF_52_UN_Showerboard DOT_uitloop_Easydrain: Dot Zijuitloop laag 40 mm; Type Id: NLRS_PF_52_UN_Showerboard DOT_uitloop_Easydrain: Dot Zijuitloop laag 40 mm; Void Diameter: 676 mm; Waterseal: 30 mm
Phasing - Phase Created: New Construction

# IfcFlowTerminal: Dot Zijuitloop laag 50 mm, NLRS_PF_52_UN_Showerboard DOT_uitloop_Easydrain:Dot Zijuitloop laag 50 mm:3372222
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, Default
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Dot; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Dot Zijuitloop laag 50 mm; URL: http://www.easydrain.nl/doucheputten/dot/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Showerboard DOT_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Dot Zijuitloop laag 50 mm
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Bottom Plate: yes; Build-in-Depth: 80 mm; Host: Level : Level 1; Tile Thickness: 9 mm
Dimensions - Do: 102 mm; Do1: 50 mm; NLRS_C_hoogte: 90 mm; NLRS_C_lengte: 1200 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.117845 m3
Identity Data - Mark: 2538; NLRS_C_code_product: EDDOT-RD; NLRS_C_omschrijving: Shower Board DOT
Mechanical - System Classification: Sanitary
Other - siphon_angle: 90 deg; Board height: 40 mm; discharge_void_length: 1500 mm; E: 23 mm; Family: NLRS_PF_52_UN_Showerboard DOT_uitloop_Easydrain: Dot Zijuitloop laag 50 mm; Family and Type: NLRS_PF_52_UN_Showerboard DOT_uitloop_Easydrain: Dot Zijuitloop laag 50 mm; H_Siphon: 59 mm; offset outlet: 66 mm; offset siphon: -9 mm; Outlet Depth: 57 mm; Outlet Length: 550 mm; Outlet Width: 550 mm; Showerboard baseheight: 31 mm; Showerboard Height: 50 mm; Showerboard Length: 1200 mm; Showerboard Width: 1100 mm; Siphon_outlet_length: 91 mm; Siphon Depth: 111 mm; Siphon Height: 80 mm; Siphon offset: -31 mm; Tile_thickness_check: 9 mm; Tile Diameter: 658 mm; Type: NLRS_PF_52_UN_Showerboard DOT_uitloop_Easydrain: Dot Zijuitloop laag 50 mm; Type Id: NLRS_PF_52_UN_Showerboard DOT_uitloop_Easydrain: Dot Zijuitloop laag 50 mm; Void Diameter: 676 mm; Waterseal: 35 mm
Phasing - Phase Created: New Construction

# IfcFlowTerminal: Dot onderuitloop 50mm, zij-ingang 40mm, NLRS_PF_52_UN_Showerboard DOT_in_uitloop_Easydrain:Dot onderuitloop 50mm, zij-ingang 40mm:3372564
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, Default
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot verticale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Dot; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Dot onderuitloop 50mm, zij-ingang 40mm; URL: http://www.easydrain.nl/doucheputten/dot/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Showerboard DOT_in_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Dot onderuitloop 50mm, zij-ingang 40mm
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Bottom Plate: yes; Build-in-Depth: 90 mm; Host: Level : Level 1; Tile Thickness: 9 mm
Dimensions - Do: 102 mm; Do1: 50 mm; Do2: 40 mm; NLRS_C_hoogte: 90 mm; NLRS_C_lengte: 1200 mm; NLRS_P_c01_diameter: 50 mm; NLRS_P_c02_diameter: 40 mm; Volume: 0.112944 m3
Identity Data - Mark: 2546; NLRS_C_code_product: EDDOT-RD; NLRS_C_omschrijving: Shower Board DOT
Mechanical - System Classification: Sanitary
Other - E1: 0 mm; siphon_angle: 180 deg; Board height: 40 mm; discharge_void_length: 1500 mm; E2: 49 mm; Family: NLRS_PF_52_UN_Showerboard DOT_in_uitloop_Easydrain: Dot onderuitloop 50mm, zij-ingang 40mm; Family and Type: NLRS_PF_52_UN_Showerboard DOT_in_uitloop_Easydrain: Dot onderuitloop 50mm, zij-ingang 40mm; H_Siphon: 90 mm; Inlet Depth: 41 mm; offset_siphon: -9 mm; Outlet Depth: 90 mm; Outlet Length: 550 mm; Outlet Width: 550 mm; Showerboard baseheight: 31 mm; Showerboard Height: 50 mm; Showerboard Length: 1200 mm; Showerboard Width: 1100 mm; Siphon_inlet_length: 91 mm; Siphon_outlet_length: 40 mm; Siphon height calculated: 90 mm; Tile_thickness_check: 9 mm; Tile Diameter: 658 mm; Type: NLRS_PF_52_UN_Showerboard DOT_in_uitloop_Easydrain: Dot onderuitloop 50mm, zij-ingang 40mm; Type Id: NLRS_PF_52_UN_Showerboard DOT_in_uitloop_Easydrain: Dot onderuitloop 50mm, zij-ingang 40mm; Void Diameter: 676 mm
Phasing - Phase Created: New Construction

# IfcFlowTerminal: Dot onderuitloop 50mm, zij-ingang 50mm, NLRS_PF_52_UN_Showerboard DOT_in_uitloop_Easydrain:Dot onderuitloop 50mm, zij-ingang 50mm:3372660
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, Default
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot verticale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Dot; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Dot onderuitloop 50mm, zij-ingang 50mm; URL: http://www.easydrain.nl/doucheputten/dot/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Showerboard DOT_in_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Dot onderuitloop 50mm, zij-ingang 50mm
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Bottom Plate: yes; Build-in-Depth: 90 mm; Host: Level : Level 1; Tile Thickness: 9 mm
Dimensions - Do: 102 mm; Do1: 50 mm; Do2: 50 mm; NLRS_C_hoogte: 90 mm; NLRS_C_lengte: 1200 mm; NLRS_P_c01_diameter: 50 mm; NLRS_P_c02_diameter: 50 mm; Volume: 0.112944 m3
Identity Data - Mark: 2548; NLRS_C_code_product: EDDOT-RD; NLRS_C_omschrijving: Shower Board DOT
Mechanical - System Classification: Sanitary
Other - E1: 0 mm; siphon_angle: 180 deg; Board height: 40 mm; discharge_void_length: 1500 mm; E2: 54 mm; Family: NLRS_PF_52_UN_Showerboard DOT_in_uitloop_Easydrain: Dot onderuitloop 50mm, zij-ingang 50mm; Family and Type: NLRS_PF_52_UN_Showerboard DOT_in_uitloop_Easydrain: Dot onderuitloop 50mm, zij-ingang 50mm; H_Siphon: 90 mm; Inlet Depth: 36 mm; offset_siphon: -9 mm; Outlet Depth: 90 mm; Outlet Length: 550 mm; Outlet Width: 550 mm; Showerboard baseheight: 31 mm; Showerboard Height: 50 mm; Showerboard Length: 1200 mm; Showerboard Width: 1100 mm; Siphon_inlet_length: 91 mm; Siphon_outlet_length: 40 mm; Siphon height calculated: 90 mm; Tile_thickness_check: 9 mm; Tile Diameter: 658 mm; Type: NLRS_PF_52_UN_Showerboard DOT_in_uitloop_Easydrain: Dot onderuitloop 50mm, zij-ingang 50mm; Type Id: NLRS_PF_52_UN_Showerboard DOT_in_uitloop_Easydrain: Dot onderuitloop 50mm, zij-ingang 50mm; Void Diameter: 676 mm
Phasing - Phase Created: New Construction
