Properties of the parts of a building model (IFC2X3), part 1 of 9

# File
Description: ViewDefinition [CoordinationView]
Time: 2017-08-18T16:08:44
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.0.1185.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Aug 18 16:08:44 2017 * Host: PC10-Erik * Database: C:\Users\ETENHA~1\AppData\Local\Temp\{B9059845-5D7F-466F-9E6D-048C82B92B9F}\ifc * Database version: 5507 * Database creation date: Fri Aug 18 16:08:29 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Aug 18 16:08:29 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Aug 18 16:08:29 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: Shower Drains NL; Phase: 18-08-2017

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Identity Data - Design Option: Main Model; Organization Name: content creation by Itannex bv for Easy Drain
Other - Category: Project Information; Client Name: Easy Drain; Project Issue Date: 07-07-2017; Project Name: Shower Drains NL; Project Status: 18-08-2017

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Identity Data - Design Option: Main Model; Organization Name: content creation by Itannex bv for Easy Drain
Other - Category: Project Information; Client Name: Easy Drain; Project Issue Date: 07-07-2017; Project Name: Shower Drains NL; Project Status: 18-08-2017

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Identity Data - Type Name: Level 1; Building Story: yes; Design Option: Main Model; Name: Level 1; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: 1 - Fixt (5)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - Constraints - tegel: no
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Multi inbouwrooster; Manufacturer: Easy Sanitary Solutions; Model: Multi; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: 1 - Fixt; URL: https://www.easydrain.nl/douchegoten/multi/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain; rooster: NLRS_PLF_52_UN_deksel_fixt_Easydrain
Pset_BuildingElementProxyCommon - Reference: 1 - Fixt
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Constraints - Moves With Nearby Elements: no; Level: Level: Level 1; default: yes; deksel_breedte: 92 mm; Host: Level : Level 1
Dimensions - NLRS_C_breedte: 92 mm; NLRS_C_hoogte: 15 mm; s: 1 mm
Identity Data - NLRS_C_omschrijving: Multi Inbouwrooster
Other - profiel_regular: yes; Family: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain: 1 - Fixt; Family and Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain: 1 - Fixt; Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain: 1 - Fixt; Type Id: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain: 1 - Fixt
Phasing - Phase Created: New Construction
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain:1 - Fixt:...) | Offset (mm) | deksel_lengte (mm) = NLRS_C_lengte (mm) | deksel_lengte_netto (mm) | Volume (m3) | Mark | NLRS_C_code_product | product_index
3068811 | 0 | 800 | 798 | 0.00109816 | 1871 | EDF 800 | 4
3069699 | 0 | 800 | 798 | 0.00109816 | 1886 | EDF 800 | 4
3083934 | 0 | 800 | 798 | 0.00109816 | 2334 | EDF 800 | 4
3083946 | 0 | 800 | 798 | 0.00109816 | 2346 | EDF 800 | 4
3153975 | 70 | 900 | 898 | 0.00123577 | 2507 | EDF 900 | 5

# IfcBuildingElementProxy: 2 - Excenter (2)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - Constraints - tegel: no
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Multi inbouwrooster; Manufacturer: Easy Sanitary Solutions; Model: Multi; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: 2 - Excenter; URL: https://www.easydrain.nl/douchegoten/multi/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain; rooster: NLRS_PLF_52_UN_deksel_excenter_Easydrain
Pset_BuildingElementProxyCommon - Reference: 2 - Excenter
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm; default: yes; deksel_breedte: 92 mm; deksel_lengte: 800 mm; Host: Level : Level 1
Dimensions - deksel_lengte_netto: 798 mm; NLRS_C_breedte: 92 mm; NLRS_C_hoogte: 15 mm; NLRS_C_lengte: 800 mm; s: 1 mm; Volume: 0.00109816 m3
Identity Data - NLRS_C_code_product: EDE 800 M; NLRS_C_omschrijving: Multi Inbouwrooster
Other - Family: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain: 2 - Excenter; Family and Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain: 2 - Excenter; product_index: 12; profiel_regular: yes; Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain: 2 - Excenter; Type Id: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain: 2 - Excenter
Phasing - Phase Created: New Construction
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain:2 - Excenter:...) | Mark
3067916 | 1859 | Identity Data - Design Option: Main Model
3083925 | 2325

# IfcBuildingElementProxy: 3 - Outside (2)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - Constraints - tegel: no
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Multi inbouwrooster; Manufacturer: Easy Sanitary Solutions; Model: Multi; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: 3 - Outside; URL: https://www.easydrain.nl/douchegoten/multi/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain; rooster: NLRS_PLF_52_UN_deksel_outside 3_Easydrain
Pset_BuildingElementProxyCommon - Reference: 3 - Outside
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Constraints - Moves With Nearby Elements: no; Offset: 0 mm; Level: Level: Level 1; default: yes; deksel_breedte: 92 mm; deksel_lengte: 800 mm; Host: Level : Level 1
Dimensions - deksel_lengte_netto: 798 mm; NLRS_C_breedte: 92 mm; NLRS_C_hoogte: 15 mm; NLRS_C_lengte: 800 mm; s: 1 mm; Volume: 0.00109816 m3
Identity Data - Design Option: Main Model; NLRS_C_code_product: EDO 800 M; NLRS_C_omschrijving: Multi Inbouwrooster
Other - profiel_regular: yes; Family: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain: 3 - Outside; Family and Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain: 3 - Outside; product_index: 20; Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain: 3 - Outside; Type Id: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain: 3 - Outside
Phasing - Phase Created: New Construction
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain:3 - Outside:...) | Mark
3068592 | 1862
3083928 | 2328

# IfcBuildingElementProxy: 4 - Move (2)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_gepolijst
Type - Constraints - tegel: no
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Multi inbouwrooster; Manufacturer: Easy Sanitary Solutions; Model: Multi; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: 4 - Move; URL: https://www.easydrain.nl/douchegoten/multi/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_gepolijst; NLRS_C_materiaal_01: NLRS_h2_RVS_gepolijst
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain; rooster: NLRS_PLF_52_UN_deksel_wave_Easydrain
Pset_BuildingElementProxyCommon - Reference: 4 - Move
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Constraints - Moves With Nearby Elements: no; Offset: 0 mm; Level: Level: Level 1; default: yes; deksel_breedte: 92 mm; deksel_lengte: 800 mm; Host: Level : Level 1
Dimensions - deksel_lengte_netto: 798 mm; NLRS_C_breedte: 92 mm; NLRS_C_hoogte: 15 mm; NLRS_C_lengte: 800 mm; s: 1 mm; Volume: 0.00109816 m3
Identity Data - NLRS_C_code_product: EDW 800 P; NLRS_C_omschrijving: Multi Inbouwrooster
Other - profiel_regular: yes; Family: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain: 4 - Move; Family and Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain: 4 - Move; product_index: 28; Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain: 4 - Move; Type Id: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain: 4 - Move
Phasing - Phase Created: New Construction
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain:4 - Move:...) | Mark
3068658 | 1865
3083931 | 2331

# IfcBuildingElementProxy: 6 - Zero (2)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - Constraints - tegel: no
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Multi inbouwrooster; Manufacturer: Easy Sanitary Solutions; Model: Multi; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: 6 - Zero; URL: https://www.easydrain.nl/douchegoten/multi/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain; rooster: std
Pset_BuildingElementProxyCommon - Reference: 6 - Zero
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm; default: yes; deksel_breedte: 92 mm; deksel_lengte: 800 mm; Host: Level : Level 1
Dimensions - deksel_lengte_netto: 798 mm; NLRS_C_breedte: 92 mm; NLRS_C_hoogte: 15 mm; NLRS_C_lengte: 800 mm; s: 1 mm; Volume: 0.00109816 m3
Identity Data - NLRS_C_code_product: EDZ 800 M; NLRS_C_omschrijving: Multi Inbouwrooster
Other - profiel_regular: yes; Family: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain: 6 - Zero; Family and Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain: 6 - Zero; product_index: 44; Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain: 6 - Zero; Type Id: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain: 6 - Zero
Phasing - Phase Created: New Construction
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain:6 - Zero:...) | Mark
3069435 | 1877 | Identity Data - Design Option: Main Model
3083937 | 2337

# IfcBuildingElementProxy: 7 - Carré (2)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - Constraints - tegel: no
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Multi inbouwrooster; Manufacturer: Easy Sanitary Solutions; Model: Multi; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: 7 - Carré; URL: https://www.easydrain.nl/douchegoten/multi/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain; rooster: NLRS_PLF_52_UN_deksel_carrer_Easydrain
Pset_BuildingElementProxyCommon - Reference: 7 - Carré
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Constraints - Moves With Nearby Elements: no; Offset: 0 mm; Level: Level: Level 1; default: yes; deksel_breedte: 92 mm; deksel_lengte: 800 mm; Host: Level : Level 1
Dimensions - deksel_lengte_netto: 798 mm; NLRS_C_breedte: 92 mm; NLRS_C_hoogte: 15 mm; NLRS_C_lengte: 800 mm; s: 1 mm; Volume: 0.00109816 m3
Identity Data - NLRS_C_code_product: EDCAR 800 M; NLRS_C_omschrijving: Multi Inbouwrooster
Other - profiel_regular: yes; Family: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain: 7 - Carré; Family and Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain: 7 - Carré; product_index: 52; Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain: 7 - Carré; Type Id: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain: 7 - Carré
Phasing - Phase Created: New Construction
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain:7 - Carré:...) | Mark
3069488 | 1880
3083940 | 2340

# IfcBuildingElementProxy: 8 - Tile (2)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - Constraints - tegel: yes
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Multi inbouwrooster; Manufacturer: Easy Sanitary Solutions; Model: Multi; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: 8 - Tile; URL: https://www.easydrain.nl/douchegoten/multi/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; rooster: std; Family Name: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain
Pset_BuildingElementProxyCommon - Reference: 8 - Tile
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm; default: no; deksel_breedte: 92 mm; deksel_lengte: 800 mm; Host: Level : Level 1
Dimensions - deksel_lengte_netto: 798 mm; NLRS_C_breedte: 92 mm; NLRS_C_hoogte: 15 mm; NLRS_C_lengte: 800 mm; s: 1 mm; Volume: 0.00110124 m3
Identity Data - NLRS_C_code_product: EDFL-8 800; NLRS_C_omschrijving: Multi Inbouwrooster
Other - Family: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain: 8 - Tile; Family and Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain: 8 - Tile; product_index: 60; profiel_regular: no; Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain: 8 - Tile; Type Id: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain: 8 - Tile
Phasing - Phase Created: New Construction
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Multi Grate_Easydrain:8 - Tile:...) | Mark
3069635 | 1883
3083943 | 2343 | Identity Data - Design Option: Main Model

# IfcBuildingElementProxy: Aqua Brilliant met tegelbakje (2)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat); Material: Rubber, Silicone, NLRS_52_WPS_ EasyDrain
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: WPS-afsluitdoek voor Aqua Brilliant; Manufacturer: Easy Sanitary Solutions; Model: WPS; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; Type Name: Aqua Brilliant met tegelbakje; URL: https://www.easydrain.nl/doucheputten/aqua-brilliant/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: Z_DO_NOT_USE_NLRS_PF_52_UN_WPS Aqua Brilliant_Easydrain
Pset_BuildingElementProxyCommon - Reference: Aqua Brilliant met tegelbakje
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Constraints - Moves With Nearby Elements: no; Level: Level: Level 1; Host: Level : Level 1; Offset: -15 mm
Dimensions - NLRS_C_breedte: 340 mm; NLRS_C_hoogte: 100 mm; NLRS_C_lengte: 340 mm; Volume: 0.000192556 m3
Identity Data - NLRS_C_code_product: WPS-AB; NLRS_C_omschrijving: WPS afdichtingsdoek voor Aqua Brilliant
Other - Family: Z_DO_NOT_USE_NLRS_PF_52_UN_WPS Aqua Brilliant_Easydrain: Aqua Brilliant met tegelbakje; Family and Type: Z_DO_NOT_USE_NLRS_PF_52_UN_WPS Aqua Brilliant_Easydrain: Aqua Brilliant met tegelbakje; Type: Z_DO_NOT_USE_NLRS_PF_52_UN_WPS Aqua Brilliant_Easydrain: Aqua Brilliant met tegelbakje; Type Id: Z_DO_NOT_USE_NLRS_PF_52_UN_WPS Aqua Brilliant_Easydrain: Aqua Brilliant met tegelbakje
Phasing - Phase Created: New Construction
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_WPS Aqua Brilliant_Easydrain:Aqua Brilliant met tegelbakje:...) | Mark
3083708 | 2262 | Identity Data - Design Option: Main Model
4257443 | 2705

# IfcBuildingElementProxy: Model Text:Model Text 1 (9)
In: Level 1
Text - Bold: no; Italic: no; Text Font: Arial; Text Size: 600 mm
Other - Category: Generic Models; Family Name: Model Text; Family: Model Text: Model Text 1; Family and Type: Model Text: Model Text 1; Type: Model Text: Model Text 1; Type Id: Model Text: Model Text 1
Identity Data - Type Name: Model Text 1; Subcategory: Generic Models
Pset_BuildingElementProxyCommon - Reference: Model Text 1
Constraints - Work Plane: Level : Level 1
Dimensions - Depth: 50 mm
Graphics - Horizontal Align: Left
Materials and Finishes - Material: Poche
Phasing - Phase Created: New Construction
Name (Model Text:...) | Text | Design Option
Model Text 1 | Wandmontage | Option 1 (primary)
Model Text 1 | Tegels/Keramiek | Option 1 (primary)
Model Text 1 | Natuursteen | Option 1 (primary)
Model Text 1 | Glas mozaïek, Kunststof en Kunstharsgebonden vloeren | Option 1 (primary)
Model Text 1 | Renovatie | Option 1 (primary)
Model Text 1 | WPS (Water Protection System) | Option Set 1 : Option 1
Model Text 1 | WTW systeem | Option 1 (primary)
Model Text 1 | Afvoerbuizen | Option Set 1 : Option 1
Model Text 1 | Shower Boards | Option Set 1 : Option 1

# IfcBuildingElementProxy: Model Text:Model Text 2 (61)
In: Level 1
Classification: 4A(74.10) standaard, algemeen (verzamelniveau) (Uniformat)
Text - Bold: no; Italic: no; Text Font: Arial; Text Size: 125 mm
Other - Category: Generic Models; Family Name: Model Text; Family: Model Text: Model Text 2; Family and Type: Model Text: Model Text 2; Type: Model Text: Model Text 2; Type Id: Model Text: Model Text 2
Identity Data - Assembly Code: 4A(74.10); Assembly Description: standaard, algemeen (verzamelniveau); Type Name: Model Text 2; Subcategory: Generic Models
Pset_BuildingElementProxyCommon - Reference: Model Text 2
Constraints - Work Plane: Level : Level 1
Dimensions - Depth: 50 mm
Graphics - Horizontal Align: Left
Phasing - Phase Created: New Construction
Name (Model Text:...) | Text | Design Option
Model Text 2 | Aqua Plus Delta | Option Set 1 : Option 1
Model Text 2 | Compact TAF WALL | Option Set 1 : Option 1
Model Text 2 | Compact TAF Modulo | Option 1 (primary)
3 x Model Text 2 | Aqua Jewels | Option Set 1 : Option 1
2 x Model Text 2 | Aqua Plus | Option 1 (primary)
Model Text 2 | Aqua | Option Set 1 : Option 1
Model Text 2 | Compact TAF | Option 1 (primary)
3 x Model Text 2 | Compact | Option Set 1 : Option 1
2 x Model Text 2 | Multi | Option 1 (primary)
Model Text 2 | Specials | Option Set 1 : Option 1
Model Text 2 | Aqua Jewels | Option 1 (primary)
2 x Model Text 2 | Aqua | Option 1 (primary)
2 x Model Text 2 | Compact | Option 1 (primary)
Model Text 2 | Specials | Option 1 (primary)
Model Text 2 | Aqua Plus | Option Set 1 : Option 1
Model Text 2 | Compact TAF 7-18mm | Option 1 (primary)
Model Text 2 | Compact TAF laag 3-13mm | Option 1 (primary)
2 x Model Text 2 | Compact TAF | Option Set 1 : Option 1
Model Text 2 | Aqua Brilliant | Option Set 1 : Option 1
Model Text 2 | Aqua Compact | Option Set 1 : Option 1
Model Text 2 | Multi Wall | Option 1 (primary)
Model Text 2 | Compact Wall | Option Set 1 : Option 1
Model Text 2 | Aqua Jewels Delta | Option Set 1 : Option 1
2 x Model Text 2 | Round Flex Class | Option 1 (primary)
Model Text 2 | S-Line | Option 1 (primary)
Model Text 2 | S-Line TAF verhoogd | Option 1 (primary)
Model Text 2 | Slim siphon XF & Slim Waste | Option Set 1 : Option 1
Model Text 2 | Slim siphon & Slim Waste | Option Set 1 : Option 1
Model Text 2 | Slimtube | Option 1 (primary)
Model Text 2 | Slimtube L = 3,2m | Option Set 1 : Option 1
2 x Model Text 2 | XS Nano | Option 1 (primary)
2 x Model Text 2 | XS Nano Wall | Option Set 1 : Option 1
2 x Model Text 2 | XS Z1 | Option 1 (primary)
Model Text 2 | XS Z4 | Option Set 1 : Option 1
Model Text 2 | XS Z2 | Option 1 (primary)
Model Text 2 | Vinyl | Option Set 1 : Option 1
Model Text 2 | Compact TAF Modulo | Option Set 1 : Option 1
Model Text 2 | Multi TAF | Option 1 (primary)
Model Text 2 | Dot | Option 1 (primary)
Model Text 2 | Square | Option Set 1 : Option 1
Model Text 2 | S-Line | Option Set 1 : Option 1
Model Text 2 | Aqua Brilliant | Option 1 (primary)
Model Text 2 | Compact M2 | Option Set 1 : Option 1
2 x Model Text 2 | M-Line | Option Set 1 : Option 1
Model Text 2 | M-Line | Option 1 (primary)
Model Text 2 | Modulo Stone | Option Set 1 : Option 1
Model Text 2 | XS Nano Wal | Option Set 1 : Option 1

# IfcBuildingElementProxy: NLRS_PLF_52_UN_Easy Drain verlengset_Easydrain (36)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - Dimensions - NLRS_P_c01_diameter: 0 mm
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Verlengset; Manufacturer: Easy Sanitary Solutions; Model: Extension Set; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Type Name: NLRS_PLF_52_UN_Easy Drain verlengset_Easydrain; URL: https://www.easydrain.nl/accessories/verlengset-multi-taf/
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: Z_DO_NOT_USE_NLRS_PF_52_UN_Extension Set_Easydrain
Pset_BuildingElementProxyCommon - Reference: NLRS_PLF_52_UN_Easy Drain verlengset_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Constraints - Moves With Nearby Elements: no; Offset: 0 mm; Level: Level: Level 1; b: 62 mm; Host: Level : Level 1; l: 0 mm; verlengset_uitlijnen: no; wandprofiel: 22 mm
Dimensions - b_rooster: 465 mm; NLRS_C_breedte: 62 mm; NLRS_C_hoogte: 2 mm; NLRS_C_lengte: 17.5 mm
Identity Data - NLRS_C_code_product: MTAF-VER - STD; NLRS_C_omschrijving: Verlengset
Materials and Finishes - material: NLRS_h2_RVS_geborsteld
Other - product_index: 1; Family: Z_DO_NOT_USE_NLRS_PF_52_UN_Extension Set_Easydrain: NLRS_PLF_52_UN_Easy Drain verlengset_Easydrain; Family and Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Extension Set_Easydrain: NLRS_PLF_52_UN_Easy Drain verlengset_Easydrain; l_berekend: 17.5 mm; l_max: 67.5 mm; l_min: 17.5 mm; Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Extension Set_Easydrain: NLRS_PLF_52_UN_Easy Drain verlengset_Easydrain; Type Id: Z_DO_NOT_USE_NLRS_PF_52_UN_Extension Set_Easydrain: NLRS_PLF_52_UN_Easy Drain verlengset_Easydrain; verleng_rechts: yes; verlengset: yes; y1: 31 mm
Phasing - Phase Created: New Construction
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Extension Set_Easydrain:NLRS_PLF_52_UN_Easy Drain verlengset_Easydrain:...) | wall | Volume (m3) | Mark | y2 (mm) | Design Option
3054631 | no | 0.00000434 | 1221 | 31
3054716 | no | 0.00000434 | 1223 | 31 | Main Model
3055100 | no | 0.00000434 | 1229 | 31 | Main Model
3055102 | no | 0.00000434 | 1231 | 31
3055273 | yes | 0.00000588 | 1233 | 53 | Main Model
3055275 | yes | 0.00000588 | 1235 | 53
3055277 | yes | 0.00000588 | 1237 | 53
3055279 | yes | 0.00000588 | 1239 | 53 | Main Model
3063846 | no | 0.00000434 | 1560 | 31 | Main Model
3063848 | no | 0.00000434 | 1562 | 31 | Main Model
3063850 | no | 0.00000434 | 1564 | 31
3063852 | no | 0.00000434 | 1566 | 31 | Main Model
3063854 | yes | 0.00000588 | 1568 | 53
3063856 | yes | 0.00000588 | 1570 | 53
3063858 | yes | 0.00000588 | 1572 | 53 | Main Model
3063860 | yes | 0.00000588 | 1574 | 53
3083259 | no | 0.00000434 | 1977 | 31
3083261 | no | 0.00000434 | 1979 | 31
3083263 | no | 0.00000434 | 1981 | 31 | Main Model
3083265 | no | 0.00000434 | 1983 | 31
3083267 | yes | 0.00000588 | 1985 | 53 | Main Model
3083269 | yes | 0.00000588 | 1987 | 53
3083271 | yes | 0.00000588 | 1989 | 53 | Main Model
3083273 | yes | 0.00000588 | 1991 | 53 | Main Model
3083735 | no | 0.00000434 | 2264 | 31 | Main Model
3083737 | no | 0.00000434 | 2266 | 31 | Main Model
3083739 | no | 0.00000434 | 2268 | 31 | Main Model
3083741 | no | 0.00000434 | 2270 | 31 | Main Model
3083743 | yes | 0.00000588 | 2272 | 53
3083745 | yes | 0.00000588 | 2274 | 53 | Main Model
3083747 | yes | 0.00000588 | 2276 | 53
3083749 | yes | 0.00000588 | 2278 | 53
3084258 | yes | 0.00000588 | 2453 | 53 | Main Model
3084260 | yes | 0.00000588 | 2455 | 53 | Main Model
3084262 | yes | 0.00000588 | 2457 | 53
3084264 | yes | 0.00000588 | 2459 | 53

# IfcFlowTerminal: Aqua Brilliant onderuitloop 50mm, NLRS_PF_52_UN_Showerboard Aqua Brilliant_Easydrain:Aqua Brilliant onderuitloop 50mm:3373870
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, Rubber, Butyl
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot verticale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Aqua Brilliant; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Aqua Brilliant onderuitloop 50mm; URL: http://www.easydrain.nl/nl/easy-drain/aqua/aqua-brilliant.html
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Showerboard Aqua Brilliant_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Brilliant onderuitloop 50mm
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; WPS: no; Host: Level : Level 1; Showerboard Length: 1200 mm; Showerboard Width: 1100 mm; Tile Thickness: 9 mm
Dimensions - D: 146 mm; Do: 50 mm; E: 61 mm; Height: 78 mm; NLRS_C_breedte: 146 mm; NLRS_C_hoogte: 78 mm; NLRS_C_lengte: 146 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.099261 m3; Z1: 125 mm
Identity Data - Mark: 2571; NLRS_C_code_product: SBAquaB; NLRS_C_omschrijving: Shower Board Aqua Brilliant
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - horizontal: no; vertical: yes; Outlet Angle: 180 deg; Family: NLRS_PF_52_UN_Showerboard Aqua Brilliant_Easydrain: Aqua Brilliant onderuitloop 50mm; Family and Type: NLRS_PF_52_UN_Showerboard Aqua Brilliant_Easydrain: Aqua Brilliant onderuitloop 50mm; Grate Thickness: 9 mm; Height_calculated: 78 mm; Length_check: 1200 mm; Outlet Length: 125 mm; R: 73 mm; ro: 25 mm; Siphon Height: 68 mm; Tile_thickness_check: 9 mm; Type: NLRS_PF_52_UN_Showerboard Aqua Brilliant_Easydrain: Aqua Brilliant onderuitloop 50mm; Type Id: NLRS_PF_52_UN_Showerboard Aqua Brilliant_Easydrain: Aqua Brilliant onderuitloop 50mm; void length: 50 mm; Waterseal: 50 mm; Width_check: 1100 mm
Phasing - Phase Created: New Construction

# IfcFlowTerminal: Aqua Brilliant zijuitloop laag 50mm, NLRS_PF_52_UN_Showerboard Aqua Brilliant_Easydrain:Aqua Brilliant zijuitloop laag 50mm:3373740
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld, Rubber, Butyl
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Aqua Brilliant; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Aqua Brilliant zijuitloop laag 50mm; URL: http://www.easydrain.nl/nl/easy-drain/aqua/aqua-brilliant.html
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Showerboard Aqua Brilliant_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Brilliant zijuitloop laag 50mm
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; WPS: no; Host: Level : Level 1; Showerboard Length: 1200 mm; Showerboard Width: 1100 mm; Tile Thickness: 9 mm
Dimensions - D: 146 mm; Do: 50 mm; E: 27.5 mm; Height: 78 mm; NLRS_C_breedte: 146 mm; NLRS_C_hoogte: 78 mm; NLRS_C_lengte: 146 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.098061 m3; Z1: 125 mm
Identity Data - Design Option: Main Model; Mark: 2570; NLRS_C_code_product: SBAquaB; NLRS_C_omschrijving: Shower Board Aqua Brilliant
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Outlet Angle: 90 deg; horizontal: yes; vertical: no; Family: NLRS_PF_52_UN_Showerboard Aqua Brilliant_Easydrain: Aqua Brilliant zijuitloop laag 50mm; Family and Type: NLRS_PF_52_UN_Showerboard Aqua Brilliant_Easydrain: Aqua Brilliant zijuitloop laag 50mm; Grate Thickness: 9 mm; Height_calculated: 78 mm; Length_check: 1200 mm; Outlet Length: 125 mm; R: 73 mm; ro: 25 mm; Siphon Height: 68 mm; Tile_thickness_check: 9 mm; Type: NLRS_PF_52_UN_Showerboard Aqua Brilliant_Easydrain: Aqua Brilliant zijuitloop laag 50mm; Type Id: NLRS_PF_52_UN_Showerboard Aqua Brilliant_Easydrain: Aqua Brilliant zijuitloop laag 50mm; void length: 1000 mm; Waterseal: 50 mm; Width_check: 1100 mm
Phasing - Phase Created: New Construction

# IfcFlowTerminal: Aqua Delta / Delta Zero (6)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot Horizontale uitloop; Manufacturer: Easy Sanitary Solutions; Model: Aqua Delta; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Aqua Delta / Delta Zero; URL: http://www.easydrain.com/en/easy-drain/aqua.html?model=6
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Aqua Delta_Zero_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Delta / Delta Zero
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Build-in-Depth: 59 mm; Host: Level : Level 1
Dimensions - D: 102 mm; Do: 50 mm; E: 34 mm; NLRS_C_breedte: 240 mm; NLRS_C_hoogte: 59 mm; NLRS_C_lengte: 240 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.00114196 m3; Z1: 91 mm
Identity Data - NLRS_C_omschrijving: Aqua Delta / Delta Zero
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Build_in_depth_calculated: 59 mm; Family: NLRS_PF_52_UN_Aqua Delta_Zero_Easydrain: Aqua Delta / Delta Zero; Family and Type: NLRS_PF_52_UN_Aqua Delta_Zero_Easydrain: Aqua Delta / Delta Zero; Grate thickness: 20 mm; H_Siphon: 50 mm; offset siphon: -20 mm; Outlet depth: 34 mm; R: 51 mm; ro: 25 mm; Type: NLRS_PF_52_UN_Aqua Delta_Zero_Easydrain: Aqua Delta / Delta Zero; Type Id: NLRS_PF_52_UN_Aqua Delta_Zero_Easydrain: Aqua Delta / Delta Zero; Wall edge: 25 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Aqua Delta_Zero_Easydrain:Aqua Delta / Delta Zero:...) | Delta | Delta Zero | Design Option | Mark | NLRS_C_code_product
3935236 | yes | no | Main Model | 2592 | EDM-DE-MSI6
3935247 | no | yes | Main Model | 2594 | EDMZ-DE-MSI6
3935284 | yes | no | Main Model | 2596 | EDM-DE-MSI6
3935285 | no | yes | Main Model | 2597 | EDMZ-DE-MSI6
3935294 | yes | no | Main Model | 2598 | EDM-DE-MSI6
3935295 | no | yes |  | 2599 | EDMZ-DE-MSI6

# IfcFlowTerminal: Aqua Delta horizontal outlet high 50mm (3)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitloop; Manufacturer: Easy Sanitary Solutions; Model: Aqua Delta; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Aqua Delta horizontal outlet high 50mm; URL: https://www.easydrain.nl/doucheputten/aqua-delta/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Aqua Delta_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Delta horizontal outlet high 50mm
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Build-in-Depth: 54 mm; Host: Level : Level 1
Dimensions - Outlet angle: 90 deg; D: 102 mm; Do: 50 mm; E: 54 mm; NLRS_C_breedte: 223 mm; NLRS_C_hoogte: 54 mm; NLRS_C_lengte: 223 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.000319508 m3; Z1: 91 mm
Identity Data - Design Option: Main Model; NLRS_C_code_product: AquaW-DE15x15-MSI1; NLRS_C_omschrijving: Aqua Delta
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - product_index: 6; Build_in_depth_calculated: 54 mm; Family: NLRS_PF_52_UN_Aqua Delta_uitloop_Easydrain: Aqua Delta horizontal outlet high 50mm; Family and Type: NLRS_PF_52_UN_Aqua Delta_uitloop_Easydrain: Aqua Delta horizontal outlet high 50mm; Grate thickness: 14 mm; H_Siphon: 90 mm; offset siphon: -14 mm; Outlet depth: 36 mm; R: 51 mm; ro: 25 mm; Siphon Height: 90 mm; Type: NLRS_PF_52_UN_Aqua Delta_uitloop_Easydrain: Aqua Delta horizontal outlet high 50mm; Type Id: NLRS_PF_52_UN_Aqua Delta_uitloop_Easydrain: Aqua Delta horizontal outlet high 50mm; Waterseal: 50 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Aqua Delta_uitloop_Easydrain:Aqua Delta horizontal outlet high 50mm:...) | Mark
3062712 | 1543
3065155 | 1821
3083657 | 2246

# IfcFlowTerminal: Aqua Delta horizontal outlet low 40mm (3)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitloop; Manufacturer: Easy Sanitary Solutions; Model: Aqua Delta; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Aqua Delta horizontal outlet low 40mm; URL: https://www.easydrain.nl/doucheputten/aqua-delta/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Aqua Delta_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Delta horizontal outlet low 40mm
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Build-in-Depth: 54 mm; Host: Level : Level 1
Dimensions - Outlet angle: 90 deg; D: 102 mm; Do: 40 mm; E: 20 mm; NLRS_C_breedte: 223 mm; NLRS_C_hoogte: 54 mm; NLRS_C_lengte: 223 mm; NLRS_P_c01_diameter: 40 mm; Volume: 0.000319508 m3; Z1: 91 mm
Identity Data - NLRS_C_code_product: AquaW-DE-MSI6; NLRS_C_omschrijving: Aqua Delta
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - product_index: 1; Build_in_depth_calculated: 54 mm; Family: NLRS_PF_52_UN_Aqua Delta_uitloop_Easydrain: Aqua Delta horizontal outlet low 40mm; Family and Type: NLRS_PF_52_UN_Aqua Delta_uitloop_Easydrain: Aqua Delta horizontal outlet low 40mm; Grate thickness: 14 mm; H_Siphon: 54 mm; offset siphon: -14 mm; Outlet depth: 34 mm; R: 51 mm; ro: 20 mm; Siphon Height: 54 mm; Type: NLRS_PF_52_UN_Aqua Delta_uitloop_Easydrain: Aqua Delta horizontal outlet low 40mm; Type Id: NLRS_PF_52_UN_Aqua Delta_uitloop_Easydrain: Aqua Delta horizontal outlet low 40mm; Waterseal: 30 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Aqua Delta_uitloop_Easydrain:Aqua Delta horizontal outlet low 40mm:...) | Mark
3062478 | 1539
3065151 | 1817 | Identity Data - Design Option: Main Model
3083653 | 2242

# IfcFlowTerminal: Aqua Delta horizontal outlet low 50mm (3)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitloop; Manufacturer: Easy Sanitary Solutions; Model: Aqua Delta; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Aqua Delta horizontal outlet low 50mm; URL: https://www.easydrain.nl/doucheputten/aqua-delta/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Aqua Delta_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Delta horizontal outlet low 50mm
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Build-in-Depth: 54 mm; Host: Level : Level 1
Dimensions - Outlet angle: 90 deg; D: 102 mm; Do: 50 mm; E: 25 mm; NLRS_C_breedte: 223 mm; NLRS_C_hoogte: 54 mm; NLRS_C_lengte: 223 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.000319508 m3; Z1: 91 mm
Identity Data - NLRS_C_code_product: AquaW-DE15x15-MSI; NLRS_C_omschrijving: Aqua Delta
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - product_index: 3; Build_in_depth_calculated: 54 mm; Family: NLRS_PF_52_UN_Aqua Delta_uitloop_Easydrain: Aqua Delta horizontal outlet low 50mm; Family and Type: NLRS_PF_52_UN_Aqua Delta_uitloop_Easydrain: Aqua Delta horizontal outlet low 50mm; Grate thickness: 14 mm; H_Siphon: 59 mm; offset siphon: -14 mm; Outlet depth: 34 mm; R: 51 mm; ro: 25 mm; Siphon Height: 59 mm; Type: NLRS_PF_52_UN_Aqua Delta_uitloop_Easydrain: Aqua Delta horizontal outlet low 50mm; Type Id: NLRS_PF_52_UN_Aqua Delta_uitloop_Easydrain: Aqua Delta horizontal outlet low 50mm; Waterseal: 30 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Aqua Delta_uitloop_Easydrain:Aqua Delta horizontal outlet low 50mm:...) | Mark | Design Option
3062651 | 1541
3065153 | 1819 | Main Model
3083655 | 2244 | Main Model

# IfcFlowTerminal: Aqua Delta onderuitloop 50mm, zij-ingang 40mm (3)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot met onderuitloop; Manufacturer: Easy Sanitary Solutions; Model: Aqua Delta; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Aqua Delta onderuitloop 50mm, zij-ingang 40mm; URL: https://www.easydrain.nl/doucheputten/aqua-delta/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Aqua Delta_in_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Delta onderuitloop 50mm, zij-ingang 40mm
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Build-in-Depth: 90 mm; Host: Level : Level 1
Dimensions - Outlet angle: 180 deg; E1: 0 mm; D: 102 mm; Do1: 50 mm; Do2: 40 mm; E2: 49 mm; NLRS_C_breedte: 223 mm; NLRS_C_hoogte: 90 mm; NLRS_C_lengte: 223 mm; NLRS_P_c01_diameter: 50 mm; NLRS_P_c02_diameter: 40 mm; Volume: 0.000319508 m3
Identity Data - NLRS_C_code_product: AquaW-DE15x15-MSI4; NLRS_C_omschrijving: Aqua Delta
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Build_in_depth_calculated: 90 mm; Family: NLRS_PF_52_UN_Aqua Delta_in_uitloop_Easydrain: Aqua Delta onderuitloop 50mm, zij-ingang 40mm; Family and Type: NLRS_PF_52_UN_Aqua Delta_in_uitloop_Easydrain: Aqua Delta onderuitloop 50mm, zij-ingang 40mm; Grate thickness: 14 mm; H_Siphon: 90 mm; Inlet Depth: 41 mm; Inlet Length: 91 mm; offset_siphon: -14 mm; Outlet depth: 90 mm; Outlet Length: 40 mm; R: 51 mm; ro: 25 mm; Siphon Height: 90 mm; Type: NLRS_PF_52_UN_Aqua Delta_in_uitloop_Easydrain: Aqua Delta onderuitloop 50mm, zij-ingang 40mm; Type Id: NLRS_PF_52_UN_Aqua Delta_in_uitloop_Easydrain: Aqua Delta onderuitloop 50mm, zij-ingang 40mm; Waterseal: 35 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Aqua Delta_in_uitloop_Easydrain:Aqua Delta onderuitloop 50mm, zij-ingang 40mm:...) | Design Option | Mark
3062932 | Main Model | 1549
3065161 | Main Model | 1827
3083663 |  | 2252

# IfcFlowTerminal: Aqua Delta onderuitloop 50mm, zij-ingang 50mm (3)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot met onderuitloop; Manufacturer: Easy Sanitary Solutions; Model: Aqua Delta; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Aqua Delta onderuitloop 50mm, zij-ingang 50mm; URL: https://www.easydrain.nl/doucheputten/aqua-delta/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Aqua Delta_in_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Delta onderuitloop 50mm, zij-ingang 50mm
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Build-in-Depth: 90 mm; Host: Level : Level 1
Dimensions - Outlet angle: 180 deg; E1: 0 mm; D: 102 mm; Do1: 50 mm; Do2: 50 mm; E2: 54 mm; NLRS_C_breedte: 223 mm; NLRS_C_hoogte: 90 mm; NLRS_C_lengte: 223 mm; NLRS_P_c01_diameter: 50 mm; NLRS_P_c02_diameter: 50 mm; Volume: 0.000319508 m3
Identity Data - NLRS_C_code_product: AquaW-DE15x15-MSI5; NLRS_C_omschrijving: Aqua Delta
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Build_in_depth_calculated: 90 mm; Family: NLRS_PF_52_UN_Aqua Delta_in_uitloop_Easydrain: Aqua Delta onderuitloop 50mm, zij-ingang 50mm; Family and Type: NLRS_PF_52_UN_Aqua Delta_in_uitloop_Easydrain: Aqua Delta onderuitloop 50mm, zij-ingang 50mm; Grate thickness: 14 mm; H_Siphon: 90 mm; Inlet Depth: 36 mm; Inlet Length: 91 mm; offset_siphon: -14 mm; Outlet depth: 90 mm; Outlet Length: 40 mm; R: 51 mm; ro: 25 mm; Siphon Height: 90 mm; Type: NLRS_PF_52_UN_Aqua Delta_in_uitloop_Easydrain: Aqua Delta onderuitloop 50mm, zij-ingang 50mm; Type Id: NLRS_PF_52_UN_Aqua Delta_in_uitloop_Easydrain: Aqua Delta onderuitloop 50mm, zij-ingang 50mm; Waterseal: 35 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Aqua Delta_in_uitloop_Easydrain:Aqua Delta onderuitloop 50mm, zij-ingang 50mm:...) | Mark
3063006 | 1551
3065163 | 1829
3083665 | 2254 | Identity Data - Design Option: Main Model

# IfcFlowTerminal: Aqua Delta vertical outlet 50mm (3)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot met onderuitloop; Manufacturer: Easy Sanitary Solutions; Model: Aqua Delta; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Aqua Delta vertical outlet 50mm; URL: https://www.easydrain.nl/doucheputten/aqua-delta/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Aqua Delta_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Delta vertical outlet 50mm
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Build-in-Depth: 54 mm; Host: Level : Level 1
Dimensions - E: 0 mm; Outlet angle: 180 deg; D: 102 mm; Do: 50 mm; NLRS_C_breedte: 223 mm; NLRS_C_hoogte: 54 mm; NLRS_C_lengte: 223 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.000319508 m3; Z1: 40 mm
Identity Data - NLRS_C_code_product: AquaW-DE15x15-MSI3; NLRS_C_omschrijving: Aqua Delta
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - product_index: 8; Build_in_depth_calculated: 54 mm; Family: NLRS_PF_52_UN_Aqua Delta_uitloop_Easydrain: Aqua Delta vertical outlet 50mm; Family and Type: NLRS_PF_52_UN_Aqua Delta_uitloop_Easydrain: Aqua Delta vertical outlet 50mm; Grate thickness: 14 mm; H_Siphon: 90 mm; offset siphon: -14 mm; Outlet depth: 90 mm; R: 51 mm; ro: 25 mm; Siphon Height: 90 mm; Type: NLRS_PF_52_UN_Aqua Delta_uitloop_Easydrain: Aqua Delta vertical outlet 50mm; Type Id: NLRS_PF_52_UN_Aqua Delta_uitloop_Easydrain: Aqua Delta vertical outlet 50mm; Waterseal: 35 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Aqua Delta_uitloop_Easydrain:Aqua Delta vertical outlet 50mm:...) | Mark
3062782 | 1545
3065157 | 1823
3083659 | 2248

# IfcFlowTerminal: Aqua Delta zijuitloop hoog 50mm, zij-ingang 40mm (3)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitloop; Manufacturer: Easy Sanitary Solutions; Model: Aqua Delta; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Aqua Delta zijuitloop hoog 50mm, zij-ingang 40mm; URL: https://www.easydrain.nl/doucheputten/aqua-delta/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Aqua Delta_in_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Delta zijuitloop hoog 50mm, zij-ingang 40mm
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Build-in-Depth: 90 mm; Host: Level : Level 1
Dimensions - Outlet angle: 90 deg; D: 102 mm; Do1: 50 mm; Do2: 40 mm; E1: 54 mm; E2: 49 mm; NLRS_C_breedte: 223 mm; NLRS_C_hoogte: 90 mm; NLRS_C_lengte: 223 mm; NLRS_P_c01_diameter: 50 mm; NLRS_P_c02_diameter: 40 mm; Volume: 0.000319508 m3
Identity Data - NLRS_C_code_product: AquaW-DE15x15-MSI2; NLRS_C_omschrijving: Aqua Delta
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Build_in_depth_calculated: 90 mm; Family: NLRS_PF_52_UN_Aqua Delta_in_uitloop_Easydrain: Aqua Delta zijuitloop hoog 50mm, zij-ingang 40mm; Family and Type: NLRS_PF_52_UN_Aqua Delta_in_uitloop_Easydrain: Aqua Delta zijuitloop hoog 50mm, zij-ingang 40mm; Grate thickness: 14 mm; H_Siphon: 90 mm; Inlet Depth: 41 mm; Inlet Length: 91 mm; offset_siphon: -14 mm; Outlet depth: 36 mm; Outlet Length: 91 mm; R: 51 mm; ro: 25 mm; Siphon Height: 90 mm; Type: NLRS_PF_52_UN_Aqua Delta_in_uitloop_Easydrain: Aqua Delta zijuitloop hoog 50mm, zij-ingang 40mm; Type Id: NLRS_PF_52_UN_Aqua Delta_in_uitloop_Easydrain: Aqua Delta zijuitloop hoog 50mm, zij-ingang 40mm; Waterseal: 50 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Aqua Delta_in_uitloop_Easydrain:Aqua Delta zijuitloop hoog 50mm, zij-ingang 40mm:...) | Mark
3062848 | 1547
3065159 | 1825 | Identity Data - Design Option: Main Model
3083661 | 2250

# IfcFlowTerminal: Aqua Jewels Delta horizontal outlet low 40mm (10)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitloop; Manufacturer: Easy Sanitary Solutions; Model: Aqua Jewels Delta; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Aqua Jewels Delta horizontal outlet low 40mm; URL: https://www.easydrain.nl/doucheputten/aqua-jewels-delta/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Aqua Jewels Delta_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Jewels Delta horizontal outlet low 40mm
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Build-in-Depth: 59 mm; Host: Level : Level 1; Tile Thickness: 5 mm
Dimensions - D: 102 mm; Do: 40 mm; E: 20 mm; NLRS_C_breedte: 240 mm; NLRS_C_hoogte: 59 mm; NLRS_C_lengte: 240 mm; NLRS_P_c01_diameter: 40 mm; Outlet angle: 90 deg; Z1: 91 mm
Identity Data - NLRS_C_omschrijving: Aqua Jewels Delta
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - product_index: 1; Build_in_depth_calculated: 59 mm; Family: NLRS_PF_52_UN_Aqua Jewels Delta_uitloop_Easydrain: Aqua Jewels Delta horizontal outlet low 40mm; Family and Type: NLRS_PF_52_UN_Aqua Jewels Delta_uitloop_Easydrain: Aqua Jewels Delta horizontal outlet low 40mm; Grate thickness: 20 mm; H_Siphon: 54 mm; offset siphon: -25 mm; Outlet depth: 39 mm; R: 51 mm; ro: 20 mm; Siphon Height: 59 mm; Tile Thickness Calculated: 5 mm; Type: NLRS_PF_52_UN_Aqua Jewels Delta_uitloop_Easydrain: Aqua Jewels Delta horizontal outlet low 40mm; Type Id: NLRS_PF_52_UN_Aqua Jewels Delta_uitloop_Easydrain: Aqua Jewels Delta horizontal outlet low 40mm; Wall edge: 40 mm; Waterseal: 30 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Aqua Jewels Delta_uitloop_Easydrain:Aqua Jewels Delta horizontal outlet low 40mm:...) | Tile | Zero | Volume (m3) | Mark | NLRS_C_code_product
3053820 | no | yes | 0.000805067 | 1196 | AJDE-ZM
3053902 | yes | no | 0.000668442 | 1198 | AJDE-ZT | Identity Data - Design Option: Main Model
3060218 | no | yes | 0.000805067 | 1413 | AJDE-ZM
3060220 | yes | no | 0.000668442 | 1415 | AJDE-ZT | Identity Data - Design Option: Main Model
3065031 | no | yes | 0.000805067 | 1697 | AJDE-ZM | Identity Data - Design Option: Main Model
3065033 | yes | no | 0.000668442 | 1699 | AJDE-ZT
3083533 | no | yes | 0.000805067 | 2122 | AJDE-ZM
3083535 | yes | no | 0.000668442 | 2124 | AJDE-ZT
3085762 | no | yes | 0.000805067 | 2487 | AJDE-ZM
3085832 | yes | no | 0.000668442 | 2489 | AJDE-ZT

# IfcFlowTerminal: Aqua Jewels Delta zijuitloop hoog 50mm, zij-ingang 40mm (10)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitloop; Manufacturer: Easy Sanitary Solutions; Model: Aqua Jewels Delta; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Aqua Jewels Delta zijuitloop hoog 50mm, zij-ingang 40mm; URL: https://www.easydrain.nl/doucheputten/aqua-jewels-delta/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Aqua Jewels Delta_in_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Jewels Delta zijuitloop hoog 50mm, zij-ingang 40mm
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Build-in-Depth: 90 mm; Host: Level : Level 1; Tile Thickness: 5 mm
Dimensions - Outlet angle: 90 deg; D: 102 mm; Do1: 50 mm; Do2: 40 mm; E1: 54 mm; E2: 49 mm; NLRS_C_breedte: 240 mm; NLRS_C_hoogte: 90 mm; NLRS_C_lengte: 240 mm; NLRS_P_c01_diameter: 50 mm; NLRS_P_c02_diameter: 40 mm; Z1: 91 mm
Identity Data - NLRS_C_omschrijving: Aqua Jewels Delta
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Build_in_depth_calculated: 90 mm; Family: NLRS_PF_52_UN_Aqua Jewels Delta_in_uitloop_Easydrain: Aqua Jewels Delta zijuitloop hoog 50mm, zij-ingang 40mm; Family and Type: NLRS_PF_52_UN_Aqua Jewels Delta_in_uitloop_Easydrain: Aqua Jewels Delta zijuitloop hoog 50mm, zij-ingang 40mm; Grate thickness: 20 mm; H_Siphon: 90 mm; Inlet Depth: 41 mm; Inlet Length: 91 mm; offset siphon: -25 mm; Outlet depth: 36 mm; R: 51 mm; ro: 25 mm; Siphon Height: 90 mm; Tile Thickness Calculated: 5 mm; Type: NLRS_PF_52_UN_Aqua Jewels Delta_in_uitloop_Easydrain: Aqua Jewels Delta zijuitloop hoog 50mm, zij-ingang 40mm; Type Id: NLRS_PF_52_UN_Aqua Jewels Delta_in_uitloop_Easydrain: Aqua Jewels Delta zijuitloop hoog 50mm, zij-ingang 40mm; Wall edge: 40 mm; Waterseal: 50 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Aqua Jewels Delta_in_uitloop_Easydrain:Aqua Jewels Delta zijuitloop hoog 50mm, zij-ingang 40mm:...) | Tile | Zero | Volume (m3) | Mark | NLRS_C_code_product
3054430 | no | yes | 0.000805067 | 1216 | AJDE-ZM | Identity Data - Design Option: Main Model
3054482 | yes | no | 0.000668442 | 1218 | AJDE-ZT
3060222 | no | yes | 0.000805067 | 1417 | AJDE-ZM | Identity Data - Design Option: Main Model
3060224 | yes | no | 0.000668442 | 1419 | AJDE-ZT
3065035 | no | yes | 0.000805067 | 1701 | AJDE-ZM
3065037 | yes | no | 0.000668442 | 1703 | AJDE-ZT
3083537 | no | yes | 0.000805067 | 2126 | AJDE-ZM
3083539 | yes | no | 0.000668442 | 2128 | AJDE-ZT
3085920 | no | yes | 0.000805067 | 2491 | AJDE-ZM | Identity Data - Design Option: Main Model
3086018 | yes | no | 0.000668442 | 2493 | AJDE-ZT | Identity Data - Design Option: Main Model

# IfcFlowTerminal: Aqua Plus Delta horizontal outlet high 50mm (12)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitloop; Manufacturer: Easy Sanitary Solutions; Model: Aqua Plus Delta; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Aqua Plus Delta horizontal outlet high 50mm; URL: https://www.easydrain.nl/doucheputten/aqua-plus-delta/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_Aqua Plus Delta_uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Aqua Plus Delta horizontal outlet high 50mm
Constraints - Siphon Orientation: 0 deg; Offset: 0 mm; Level: Level: Level 1; Build-in-Depth: 54 mm; Host: Level : Level 1
Dimensions - Outlet angle: 90 deg; D: 102 mm; Do: 50 mm; E: 54 mm; NLRS_C_hoogte: 54 mm; NLRS_P_c01_diameter: 50 mm; Z1: 91 mm
Identity Data - NLRS_C_omschrijving: Aqua Plus Delta
Mechanical - NLRS_P_c01_volumestroom: 0 m3/s; System Classification: Sanitary
Other - Build_in_depth_calculated: 54 mm; Family: NLRS_PF_52_UN_Aqua Plus Delta_uitloop_Easydrain: Aqua Plus Delta horizontal outlet high 50mm; Family and Type: NLRS_PF_52_UN_Aqua Plus Delta_uitloop_Easydrain: Aqua Plus Delta horizontal outlet high 50mm; Flange Height: 25 mm; H_Siphon: 90 mm; Outlet depth: 36 mm; R: 51 mm; ro: 25 mm; Siphon Height: 90 mm; Type: NLRS_PF_52_UN_Aqua Plus Delta_uitloop_Easydrain: Aqua Plus Delta horizontal outlet high 50mm; Type Id: NLRS_PF_52_UN_Aqua Plus Delta_uitloop_Easydrain: Aqua Plus Delta horizontal outlet high 50mm; Waterseal: 50 mm
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_Aqua Plus Delta_uitloop_Easydrain:Aqua Plus Delta horizontal outlet high 50mm:...) | Zero | Flange | NLRS_C_breedte (mm) = NLRS_C_lengte (mm) | Volume (m3) | Mark | NLRS_C_code_product | Draingoot offset (mm) | Grate thickness (mm) | offset siphon (mm)
3060430 | no | no | 245 | 0.000260188 | 1425 | Aqua+WDE-MSI1 | 19 | 10 | -10
3060498 | no | yes | 240 | 0.00049899 | 1433 | EDMW-DE-MSI1 | 12 | 20 | -20 | Identity Data - Design Option: Main Model
3060568 | yes | no | 240 | 0.00049899 | 1441 | EDMZW-DE-MSI1 | 12 | 20 | -20 | Identity Data - Design Option: Main Model
3065043 | no | no | 245 | 0.000260188 | 1709 | Aqua+WDE-MSI1 | 19 | 10 | -10 | Identity Data - Design Option: Main Model
3065051 | no | yes | 240 | 0.00049899 | 1717 | EDMW-DE-MSI1 | 12 | 20 | -20 | Identity Data - Design Option: Main Model
3065059 | yes | no | 240 | 0.00049899 | 1725 | EDMZW-DE-MSI1 | 12 | 20 | -20
