Properties of the parts of a building model (IFC2X3), part 9 of 9

# IfcFlowTerminal: XS-Z4 Chrome Plated with M2 flat siphon (2)
Dimensions - Do: 40 mm; Do1: 50 mm; NLRS_C_breedte: 70 mm; NLRS_C_hoogte: 66 mm; NLRS_C_lengte: 900 mm; NLRS_P_c01_diameter: 40 mm; Volume: 0.0030322 m3
Identity Data - NLRS_C_code_product: XS-TAF 900-Z4P; NLRS_C_omschrijving: XS-Z4 - Chrome Plated Steel
Mechanical - System Classification: Sanitary
Other - Outlet angle: 90 deg; m2_vertical: no; Ref_line_angle: 180 deg; m2_flat: yes; Siphon Connection: no; standard_siphon: no; build_in_depth_calculated: 66 mm; Draingoot Depth: 24 mm; Draingoot Width: 70 mm; Family: NLRS_PF_52_UN_XS Z4 Complete Set_Easydrain: XS-Z4 Chrome Plated with M2 flat siphon; Family and Type: NLRS_PF_52_UN_XS Z4 Complete Set_Easydrain: XS-Z4 Chrome Plated with M2 flat siphon; Flange Width: 70 mm; L_/_: 17.5 mm; Leg length: 66 mm; Length_calculated: 900 mm; max_length: 1200 mm; min_length: 800 mm; Outlet_pos_length: 25 mm; Outlet_pos_width: 25 mm; Outlet depth: 44 mm; Outlet Length: 175 mm; Ro: 20 mm; Ro1: 25 mm; Siphon Depth: 66 mm; Siphon Width: 120 mm; Tile_thickness_calculated: 5 mm; Type: NLRS_PF_52_UN_XS Z4 Complete Set_Easydrain: XS-Z4 Chrome Plated with M2 flat siphon; Type Id: NLRS_PF_52_UN_XS Z4 Complete Set_Easydrain: XS-Z4 Chrome Plated with M2 flat siphon
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_XS Z4 Complete Set_Easydrain:XS-Z4 Chrome Plated with M2 flat siphon:...) | Mark
3083174 | 1964
3084052 | 2404

# IfcFlowTerminal: XS-Z4 Chrome Plated with M2 vertical outlet (2)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_h2_RVS_geborsteld
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot verticale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: XS Z-4; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: XS-Z4 Chrome Plated with M2 vertical outlet; URL: https://www.easydrain.nl/douchegoten/xs-design-z-4/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: NLRS_PF_52_UN_XS Z4 Complete Set_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: XS-Z4 Chrome Plated with M2 vertical outlet
Constraints - Level: Level: Level 1; Siphon Orientation: 0 deg; Offset: 0 mm; Build-in-Depth: 66 mm; Grate Length: 900 mm; Host: Level : Level 1; Tile Thickness: 5 mm
Dimensions - Do: 50 mm; Do1: 50 mm; NLRS_C_breedte: 70 mm; NLRS_C_hoogte: 66 mm; NLRS_C_lengte: 900 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.00310062 m3
Identity Data - NLRS_C_code_product: XS-TAF 900-Z4P; NLRS_C_omschrijving: XS-Z4 - Chrome Plated Steel
Mechanical - System Classification: Sanitary
Other - Outlet angle: 180 deg; m2_vertical: yes; m2_flat: no; Ref_line_angle: 180 deg; Siphon Connection: yes; standard_siphon: no; build_in_depth_calculated: 66 mm; Draingoot Depth: 24 mm; Draingoot Width: 70 mm; Family: NLRS_PF_52_UN_XS Z4 Complete Set_Easydrain: XS-Z4 Chrome Plated with M2 vertical outlet; Family and Type: NLRS_PF_52_UN_XS Z4 Complete Set_Easydrain: XS-Z4 Chrome Plated with M2 vertical outlet; Flange Width: 70 mm; L_/_: 17.5 mm; Leg length: 66 mm; Length_calculated: 900 mm; max_length: 1200 mm; min_length: 800 mm; Outlet_pos_length: 25 mm; Outlet_pos_width: 50 mm; Outlet depth: 24 mm; Outlet Length: 213 mm; Ro: 25 mm; Ro1: 25 mm; Siphon Depth: 66 mm; Siphon Width: 120 mm; Tile_thickness_calculated: 5 mm; Type: NLRS_PF_52_UN_XS Z4 Complete Set_Easydrain: XS-Z4 Chrome Plated with M2 vertical outlet; Type Id: NLRS_PF_52_UN_XS Z4 Complete Set_Easydrain: XS-Z4 Chrome Plated with M2 vertical outlet
Phasing - Phase Created: New Construction
Name (NLRS_PF_52_UN_XS Z4 Complete Set_Easydrain:XS-Z4 Chrome Plated with M2 vertical outlet:...) | Mark
3083179 | 1965
3084053 | 2405 | Identity Data - Design Option: Main Model

# IfcFlowTerminal: Zero+ Stainless Steel 10x10 (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_52_WPS_ EasyDrain, NLRS_h2_RVS_geborsteld, Roestvrijstaal,geborsteld
Type - Dimensions - Grate Length: 100 mm; Grate Width: 100 mm
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Aqua Jewels Quatro; Manufacturer: Easy Sanitary Solutions; Model: Aqua Jewels Quatro; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Zero+ Stainless Steel 10x10; URL: https://www.easydrain.nl/doucheputten/aqua-jewels-quattro/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Zero+ Stainless Steel 10x10
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Host: Level : Level 1; Offset: 0 mm; Tile Thickness: 5 mm; WPS: yes
Dimensions - Flange length: 160 mm; Flange width: 160 mm; Grate Depth: 20 mm; NLRS_C_breedte: 100 mm; NLRS_C_lengte: 100 mm; Volume: 0.0005105 m3
Identity Data - NLRS_C_code_product: AJQ-10X10-ZM; NLRS_C_omschrijving: Aqua Jewels Quatro - Zero+ Stainless Steel
Other - Family: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Zero+ Stainless Steel 10x10; Family and Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Zero+ Stainless Steel 10x10; offset_length: 0 mm; offset_width: 0 mm; s: 5 mm; Tile: yes; Tile_Thickness_calculated: 5 mm; Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Zero+ Stainless Steel 10x10; Type Id: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Zero+ Stainless Steel 10x10; WPS Length: 330 mm
Phasing - Phase Created: New Construction
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain:Zero+ Stainless Steel 10x10:...) | Build-in-Depth (mm) = NLRS_C_hoogte (mm) = Build_in_depth_calculated (mm) | Mark
3051619 | 59 | 1054
3053435 | 90 | 1153 | Identity Data - Design Option: Main Model
3060083 | 59 | 1325
3060128 | 90 | 1370 | Identity Data - Design Option: Main Model
3064943 | 59 | 1609
3064988 | 90 | 1654 | Identity Data - Design Option: Main Model
3083445 | 59 | 2034
3083490 | 90 | 2079

# IfcFlowTerminal: Zero+ Stainless Steel 15x15 (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_52_WPS_ EasyDrain, NLRS_h2_RVS_geborsteld, Roestvrijstaal,geborsteld
Type - Dimensions - Grate Length: 150 mm; Grate Width: 150 mm
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Aqua Jewels Quatro; Manufacturer: Easy Sanitary Solutions; Model: Aqua Jewels Quatro; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Zero+ Stainless Steel 15x15; URL: https://www.easydrain.nl/doucheputten/aqua-jewels-quattro/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Zero+ Stainless Steel 15x15
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm; WPS: yes; Host: Level : Level 1; Tile Thickness: 5 mm
Dimensions - Flange length: 210 mm; Flange width: 210 mm; Grate Depth: 20 mm; NLRS_C_breedte: 150 mm; NLRS_C_lengte: 150 mm; Volume: 0.000855 m3
Identity Data - NLRS_C_code_product: AJQ-15X15-ZM; NLRS_C_omschrijving: Aqua Jewels Quatro - Zero+ Stainless Steel
Other - Tile: yes; Family: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Zero+ Stainless Steel 15x15; Family and Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Zero+ Stainless Steel 15x15; offset_length: 5 mm; offset_width: 10 mm; s: 5 mm; Tile_Thickness_calculated: 5 mm; Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Zero+ Stainless Steel 15x15; Type Id: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Zero+ Stainless Steel 15x15; WPS Length: 330 mm
Phasing - Phase Created: New Construction
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain:Zero+ Stainless Steel 15x15:...) | Build-in-Depth (mm) = NLRS_C_hoogte (mm) = Build_in_depth_calculated (mm) | Mark
3051700 | 59 | 1057 | Identity Data - Design Option: Main Model
3053438 | 90 | 1156 | Identity Data - Design Option: Main Model
3060086 | 59 | 1328
3060131 | 90 | 1373 | Identity Data - Design Option: Main Model
3064946 | 59 | 1612
3064991 | 90 | 1657
3083448 | 59 | 2037
3083493 | 90 | 2082

# IfcFlowTerminal: Zero+ Stainless Steel 20x20 (8)
In: Level 1
Type - PredefinedType: GULLYTRAP; Classification: 52.31 (Uniformat); Material: NLRS_52_WPS_ EasyDrain, NLRS_h2_RVS_geborsteld, Roestvrijstaal,geborsteld
Type - Dimensions - Grate Length: 200 mm; Grate Width: 200 mm
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Aqua Jewels Quatro; Manufacturer: Easy Sanitary Solutions; Model: Aqua Jewels Quatro; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24.14; OmniClass Title: Deck Waste Water Drains; Type Name: Zero+ Stainless Steel 20x20; URL: https://www.easydrain.nl/doucheputten/aqua-jewels-quattro/
Type - Materials and Finishes - NLRS_C_materiaal: NLRS_h2_RVS_geborsteld; NLRS_C_materiaal_01: NLRS_h2_RVS_geborsteld
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: Zero+ Stainless Steel 20x20
Constraints - Moves With Nearby Elements: no; Offset: 0 mm; WPS: yes; Level: Level: Level 1; Host: Level : Level 1; Tile Thickness: 5 mm
Dimensions - Flange length: 260 mm; Flange width: 260 mm; Grate Depth: 20 mm; NLRS_C_breedte: 200 mm; NLRS_C_lengte: 200 mm; Volume: 0.0013345 m3
Identity Data - NLRS_C_code_product: AJQ-20X20-ZM; NLRS_C_omschrijving: Aqua Jewels Quatro - Zero+ Stainless Steel
Other - Tile: yes; Family: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Zero+ Stainless Steel 20x20; Family and Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Zero+ Stainless Steel 20x20; offset_length: 5 mm; offset_width: 10 mm; s: 5 mm; Tile_Thickness_calculated: 5 mm; Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Zero+ Stainless Steel 20x20; Type Id: Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain: Zero+ Stainless Steel 20x20; WPS Length: 330 mm
Phasing - Phase Created: New Construction
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Aqua Jewels Quattro Complete_Easydrain:Zero+ Stainless Steel 20x20:...) | Build-in-Depth (mm) = NLRS_C_hoogte (mm) = Build_in_depth_calculated (mm) | Mark
3051815 | 59 | 1060 | Identity Data - Design Option: Main Model
3053441 | 90 | 1159 | Identity Data - Design Option: Main Model
3060089 | 59 | 1331
3060134 | 90 | 1376
3064949 | 59 | 1615
3064994 | 90 | 1660
3083451 | 59 | 2040 | Identity Data - Design Option: Main Model
3083496 | 90 | 2085

# IfcFlowTerminal: onderuitloop 50mm (33)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat)
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot verticale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Multi; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24; OmniClass Title: Waste Water Drains; Type Name: onderuitloop 50mm; URL: http://www.easydrain.nl/nl/easy-drain/multi/multi.html
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: onderuitloop 50mm
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Siphon Orientation: 0 deg; Host: Level : Level 1; Waterseal: 35 mm
Dimensions - E: 0 mm; a: 270 deg; D: 102 mm; Do: 50 mm; NLRS_C_diameter: 102 mm; NLRS_C_hoogte: 90 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.000794344 m3; Z1: 40 mm
Identity Data - NLRS_C_code_product: EDMSI 3; NLRS_C_omschrijving: Multi Sifon
Other - product_index: 8; Family: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon uitloop_Easydrain: onderuitloop 50mm; Family and Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon uitloop_Easydrain: onderuitloop 50mm; H_calculated: 90 mm; H_siphon: 87 mm; R: 51 mm; ro: 25 mm; Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon uitloop_Easydrain: onderuitloop 50mm; Type Id: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon uitloop_Easydrain: onderuitloop 50mm
Phasing - Phase Created: New Construction
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon uitloop_Easydrain:onderuitloop 50mm:...) | H (mm) | Offset (mm) | Design Option | Mark
3060449 | 54 | -10 | Main Model | 1428
3060501 | 54 | -10 | Main Model | 1436
3060571 | 54 | -10 |  | 1444
3061101 | 59 | -20.5 |  | 1476
3061526 | 59 | -20.5 | Main Model | 1490
3061598 | 59 | -20.5 | Main Model | 1504
3062070 | 59 | -11 |  | 1518
3062438 | 59 | -11 |  | 1532
3062783 | 54 | -14 |  | 1546
3065046 | 54 | -10 |  | 1712
3065054 | 54 | -10 | Main Model | 1720
3065062 | 54 | -10 | Main Model | 1728
3065088 | 59 | -20.5 | Main Model | 1754
3065102 | 59 | -20.5 |  | 1768
3065116 | 59 | -20.5 |  | 1782
3065130 | 59 | -11 | Main Model | 1796
3065144 | 59 | -11 | Main Model | 1810
3065158 | 54 | -14 | Main Model | 1824
3083548 | 54 | -10 | Main Model | 2137
3083556 | 54 | -10 | Main Model | 2145
3083564 | 54 | -10 | Main Model | 2153
3083590 | 59 | -20.5 |  | 2179
3083604 | 59 | -20.5 | Main Model | 2193
3083618 | 59 | -20.5 | Main Model | 2207
3083632 | 59 | -11 | Main Model | 2221
3083646 | 59 | -11 |  | 2235
3083660 | 54 | -14 |  | 2249
3084117 | 54 | -10 |  | 2417
3084125 | 54 | -10 | Main Model | 2425
3084133 | 54 | -10 | Main Model | 2433
3085198 | 59 | -27 | Main Model | 2474
3372372 | 80 | -9 | Main Model | 2543
3373049 | 80 | -9 |  | 2557

# IfcFlowTerminal: onderuitloop 50mm, zij-ingang 40mm (33)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat)
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot verticale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Multi; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24; OmniClass Title: Waste Water Drains; Type Name: onderuitloop 50mm, zij-ingang 40mm; URL: http://www.easydrain.nl/nl/easy-drain/multi/multi.html
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon in-uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: onderuitloop 50mm, zij-ingang 40mm
Constraints - Moves With Nearby Elements: no; Siphon Orientation: 0 deg; Level: Level: Level 1; H: 90 mm; Host: Level : Level 1; Waterseal: 35 mm
Dimensions - a: 270 deg; E1: 0 mm; D: 102 mm; Do1: 50 mm; Do2: 40 mm; E2: 49 mm; NLRS_C_diameter: 102 mm; NLRS_C_hoogte: 90 mm; NLRS_P_c01_diameter: 50 mm; NLRS_P_c02_diameter: 40 mm; Volume: 0.000845782 m3; Z1: 40 mm
Identity Data - NLRS_C_code_product: EDMSI 4; NLRS_C_omschrijving: Multi Sifon
Other - Family: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon in-uitloop_Easydrain: onderuitloop 50mm, zij-ingang 40mm; Family and Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon in-uitloop_Easydrain: onderuitloop 50mm, zij-ingang 40mm; H_calculated: 90 mm; H_siphon: 87 mm; R: 51 mm; ro: 25 mm; ro2: 20 mm; Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon in-uitloop_Easydrain: onderuitloop 50mm, zij-ingang 40mm; Type Id: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon in-uitloop_Easydrain: onderuitloop 50mm, zij-ingang 40mm
Phasing - Phase Created: New Construction
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon in-uitloop_Easydrain:onderuitloop 50mm, zij-ingang 40mm:...) | Offset (mm) | Mark
3060625 | -10 | 1448
3060633 | -10 | 1456 | Identity Data - Design Option: Main Model
3060641 | -10 | 1464 | Identity Data - Design Option: Main Model
3061262 | -20.5 | 1480 | Identity Data - Design Option: Main Model
3061530 | -20.5 | 1494 | Identity Data - Design Option: Main Model
3061602 | -20.5 | 1508
3062380 | -11 | 1524 | Identity Data - Design Option: Main Model
3062444 | -11 | 1538 | Identity Data - Design Option: Main Model
3062933 | -14 | 1550
3065066 | -10 | 1732 | Identity Data - Design Option: Main Model
3065072 | -10 | 1738
3065078 | -10 | 1744
3065092 | -20.5 | 1758
3065106 | -20.5 | 1772
3065120 | -20.5 | 1786 | Identity Data - Design Option: Main Model
3065136 | -11 | 1802
3065150 | -11 | 1816
3065162 | -14 | 1828
3083568 | -10 | 2157 | Identity Data - Design Option: Main Model
3083574 | -10 | 2163 | Identity Data - Design Option: Main Model
3083580 | -10 | 2169 | Identity Data - Design Option: Main Model
3083594 | -20.5 | 2183 | Identity Data - Design Option: Main Model
3083608 | -20.5 | 2197
3083622 | -20.5 | 2211
3083638 | -11 | 2227 | Identity Data - Design Option: Main Model
3083652 | -11 | 2241
3083664 | -14 | 2253
3084137 | -10 | 2437
3084143 | -10 | 2443
3084149 | -10 | 2449 | Identity Data - Design Option: Main Model
3085332 | -27 | 2480 | Identity Data - Design Option: Main Model
3372565 | -9 | 2547
3373209 | -9 | 2561 | Identity Data - Design Option: Main Model

# IfcFlowTerminal: onderuitloop 50mm, zij-ingang 50mm (27)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat)
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot verticale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Multi; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24; OmniClass Title: Waste Water Drains; Type Name: onderuitloop 50mm, zij-ingang 50mm; URL: http://www.easydrain.nl/nl/easy-drain/multi/multi.html
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon in-uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: onderuitloop 50mm, zij-ingang 50mm
Constraints - Moves With Nearby Elements: no; Siphon Orientation: 0 deg; Level: Level: Level 1; H: 90 mm; Host: Level : Level 1; Waterseal: 35 mm
Dimensions - a: 270 deg; E1: 0 mm; D: 102 mm; Do1: 50 mm; Do2: 50 mm; E2: 54 mm; NLRS_C_diameter: 102 mm; NLRS_C_hoogte: 90 mm; NLRS_P_c01_diameter: 50 mm; NLRS_P_c02_diameter: 50 mm; Volume: 0.000875912 m3; Z1: 40 mm
Identity Data - NLRS_C_code_product: EDMSI 5; NLRS_C_omschrijving: Multi Sifon
Other - Family: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon in-uitloop_Easydrain: onderuitloop 50mm, zij-ingang 50mm; Family and Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon in-uitloop_Easydrain: onderuitloop 50mm, zij-ingang 50mm; H_calculated: 90 mm; H_siphon: 87 mm; R: 51 mm; ro: 25 mm; ro2: 25 mm; Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon in-uitloop_Easydrain: onderuitloop 50mm, zij-ingang 50mm; Type Id: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon in-uitloop_Easydrain: onderuitloop 50mm, zij-ingang 50mm
Phasing - Phase Created: New Construction
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon in-uitloop_Easydrain:onderuitloop 50mm, zij-ingang 50mm:...) | Offset (mm) | Mark | Design Option
3060627 | -10 | 1450
3060635 | -10 | 1458
3060643 | -10 | 1466 | Main Model
3061368 | -20.5 | 1482 | Main Model
3062252 | -11 | 1522
3062442 | -11 | 1536
3063007 | -14 | 1552 | Main Model
3065068 | -10 | 1734
3065074 | -10 | 1740 | Main Model
3065080 | -10 | 1746
3065094 | -20.5 | 1760 | Main Model
3065134 | -11 | 1800
3065148 | -11 | 1814 | Main Model
3065164 | -14 | 1830 | Main Model
3083570 | -10 | 2159 | Main Model
3083576 | -10 | 2165 | Main Model
3083582 | -10 | 2171 | Main Model
3083596 | -20.5 | 2185 | Main Model
3083636 | -11 | 2225
3083650 | -11 | 2239 | Main Model
3083666 | -14 | 2255
3084139 | -10 | 2439 | Main Model
3084145 | -10 | 2445 | Main Model
3084151 | -10 | 2451
3085384 | -27 | 2483
3372661 | -9 | 2549 | Main Model
3373301 | -9 | 2563

# IfcFlowTerminal: zijuitloop hoog 50mm (33)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat)
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Multi; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24; OmniClass Title: Waste Water Drains; Type Name: zijuitloop hoog 50mm; URL: http://www.easydrain.nl/nl/easy-drain/multi/multi.html
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: zijuitloop hoog 50mm
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Siphon Orientation: 0 deg; Host: Level : Level 1; Waterseal: 50 mm
Dimensions - a: 180 deg; D: 102 mm; Do: 50 mm; E: 54 mm; NLRS_C_diameter: 102 mm; NLRS_C_hoogte: 90 mm; NLRS_P_c01_diameter: 50 mm; Volume: 0.000797465 m3; Z1: 91 mm
Identity Data - NLRS_C_code_product: EDMSI 1; NLRS_C_omschrijving: Multi Sifon
Other - Family: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon uitloop_Easydrain: zijuitloop hoog 50mm; Family and Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon uitloop_Easydrain: zijuitloop hoog 50mm; H_calculated: 90 mm; H_siphon: 87 mm; product_index: 6; R: 51 mm; ro: 25 mm; Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon uitloop_Easydrain: zijuitloop hoog 50mm; Type Id: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon uitloop_Easydrain: zijuitloop hoog 50mm
Phasing - Phase Created: New Construction
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon uitloop_Easydrain:zijuitloop hoog 50mm:...) | H (mm) | Offset (mm) | Mark
3060431 | 54 | -10 | 1426
3060499 | 54 | -10 | 1434
3060569 | 54 | -10 | 1442
3061044 | 59 | -20.5 | 1474 | Identity Data - Design Option: Main Model
3061524 | 59 | -20.5 | 1488 | Identity Data - Design Option: Main Model
3061596 | 59 | -20.5 | 1502 | Identity Data - Design Option: Main Model
3062003 | 59 | -11 | 1516
3062436 | 59 | -11 | 1530
3062713 | 54 | -14 | 1544
3065044 | 54 | -10 | 1710 | Identity Data - Design Option: Main Model
3065052 | 54 | -10 | 1718 | Identity Data - Design Option: Main Model
3065060 | 54 | -10 | 1726
3065086 | 59 | -20.5 | 1752
3065100 | 59 | -20.5 | 1766
3065114 | 59 | -20.5 | 1780 | Identity Data - Design Option: Main Model
3065128 | 59 | -11 | 1794 | Identity Data - Design Option: Main Model
3065142 | 59 | -11 | 1808
3065156 | 54 | -14 | 1822 | Identity Data - Design Option: Main Model
3083546 | 54 | -10 | 2135
3083554 | 54 | -10 | 2143 | Identity Data - Design Option: Main Model
3083562 | 54 | -10 | 2151 | Identity Data - Design Option: Main Model
3083588 | 59 | -20.5 | 2177 | Identity Data - Design Option: Main Model
3083602 | 59 | -20.5 | 2191
3083616 | 59 | -20.5 | 2205 | Identity Data - Design Option: Main Model
3083630 | 59 | -11 | 2219
3083644 | 59 | -11 | 2233
3083658 | 54 | -14 | 2247
3084115 | 54 | -10 | 2415
3084123 | 54 | -10 | 2423
3084131 | 54 | -10 | 2431 | Identity Data - Design Option: Main Model
3085098 | 54 | -27 | 2471
3372300 | 80 | -9 | 2541 | Identity Data - Design Option: Main Model
3372960 | 80 | -9 | 2555 | Identity Data - Design Option: Main Model

# IfcFlowTerminal: zijuitloop hoog 50mm, zij-ingang 40mm (145)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat)
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Multi; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24; OmniClass Title: Waste Water Drains; Type Name: zijuitloop hoog 50mm, zij-ingang 40mm; URL: http://www.easydrain.nl/nl/easy-drain/multi/multi.html
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon in-uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: zijuitloop hoog 50mm, zij-ingang 40mm
Constraints - Moves With Nearby Elements: no; Siphon Orientation: 0 deg; Level: Level: Level 1; Host: Level : Level 1; Waterseal: 50 mm
Dimensions - a: 180 deg; D: 102 mm; Do1: 50 mm; Do2: 40 mm; E1: 54 mm; E2: 49 mm; NLRS_C_diameter: 102 mm; NLRS_C_hoogte: 90 mm; NLRS_P_c01_diameter: 50 mm; NLRS_P_c02_diameter: 40 mm; Volume: 0.000848903 m3; Z1: 91 mm
Identity Data - NLRS_C_code_product: EDMSI 2; NLRS_C_omschrijving: Multi Sifon
Other - Family: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon in-uitloop_Easydrain: zijuitloop hoog 50mm, zij-ingang 40mm; Family and Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon in-uitloop_Easydrain: zijuitloop hoog 50mm, zij-ingang 40mm; H_calculated: 90 mm; H_siphon: 87 mm; R: 51 mm; ro: 25 mm; ro2: 20 mm; Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon in-uitloop_Easydrain: zijuitloop hoog 50mm, zij-ingang 40mm; Type Id: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon in-uitloop_Easydrain: zijuitloop hoog 50mm, zij-ingang 40mm
Phasing - Phase Created: New Construction
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon in-uitloop_Easydrain:zijuitloop hoog 50mm, zij-ingang 40mm:...) | H (mm) | Offset (mm) | Mark
3053434 | 90 | -25 | 1152
3053437 | 90 | -25 | 1155
3053440 | 90 | -25 | 1158 | Identity Data - Design Option: Main Model
3053443 | 90 | -25 | 1161 | Identity Data - Design Option: Main Model
3053446 | 90 | -25 | 1164
3053449 | 90 | -25 | 1167
3053452 | 90 | -25 | 1170
3053455 | 90 | -25 | 1173 | Identity Data - Design Option: Main Model
3053458 | 90 | -25 | 1176 | Identity Data - Design Option: Main Model
3053461 | 90 | -25 | 1179
3053464 | 90 | -25 | 1182 | Identity Data - Design Option: Main Model
3053467 | 90 | -25 | 1185
3053470 | 90 | -25 | 1188
3053473 | 90 | -25 | 1191
3053476 | 90 | -25 | 1194
3054431 | 90 | -25 | 1217 | Identity Data - Design Option: Main Model
3054483 | 90 | -25 | 1219 | Identity Data - Design Option: Main Model
3058502 | 90 | -27 | 1284
3058589 | 90 | -27 | 1287 | Identity Data - Design Option: Main Model
3058725 | 90 | -27 | 1290 | Identity Data - Design Option: Main Model
3058728 | 90 | -27 | 1293
3060127 | 90 | -25 | 1369
3060130 | 90 | -25 | 1372
3060133 | 90 | -25 | 1375 | Identity Data - Design Option: Main Model
3060136 | 90 | -25 | 1378 | Identity Data - Design Option: Main Model
3060139 | 90 | -25 | 1381 | Identity Data - Design Option: Main Model
3060142 | 90 | -25 | 1384 | Identity Data - Design Option: Main Model
3060145 | 90 | -25 | 1387 | Identity Data - Design Option: Main Model
3060148 | 90 | -25 | 1390 | Identity Data - Design Option: Main Model
3060151 | 90 | -25 | 1393
3060154 | 90 | -25 | 1396 | Identity Data - Design Option: Main Model
3060157 | 90 | -25 | 1399
3060160 | 90 | -25 | 1402 | Identity Data - Design Option: Main Model
3060163 | 90 | -25 | 1405
3060166 | 90 | -25 | 1408
3060169 | 90 | -25 | 1411
3060223 | 90 | -25 | 1418
3060225 | 90 | -25 | 1420
3060623 | 90 | -10 | 1446 | Identity Data - Design Option: Main Model
3060631 | 90 | -10 | 1454
3060639 | 90 | -10 | 1462 | Identity Data - Design Option: Main Model
3061182 | 90 | -20.5 | 1478 | Identity Data - Design Option: Main Model
3061528 | 90 | -20.5 | 1492
3061532 | 90 | -20.5 | 1496
3061600 | 90 | -20.5 | 1506 | Identity Data - Design Option: Main Model
3061604 | 90 | -20.5 | 1510 | Identity Data - Design Option: Main Model
3062152 | 90 | -11 | 1520
3062440 | 90 | -11 | 1534 | Identity Data - Design Option: Main Model
3062849 | 90 | -14 | 1548
3064987 | 90 | -25 | 1653 | Identity Data - Design Option: Main Model
3064990 | 90 | -25 | 1656 | Identity Data - Design Option: Main Model
3064993 | 90 | -25 | 1659
3064996 | 90 | -25 | 1662
3064999 | 90 | -25 | 1665 | Identity Data - Design Option: Main Model
3065002 | 90 | -25 | 1668 | Identity Data - Design Option: Main Model
3065005 | 90 | -25 | 1671
3065008 | 90 | -25 | 1674 | Identity Data - Design Option: Main Model
3065011 | 90 | -25 | 1677
3065014 | 90 | -25 | 1680
3065017 | 90 | -25 | 1683 | Identity Data - Design Option: Main Model
3065020 | 90 | -25 | 1686 | Identity Data - Design Option: Main Model
3065023 | 90 | -25 | 1689 | Identity Data - Design Option: Main Model
3065026 | 90 | -25 | 1692 | Identity Data - Design Option: Main Model
3065029 | 90 | -25 | 1695
3065036 | 90 | -25 | 1702 | Identity Data - Design Option: Main Model
3065038 | 90 | -25 | 1704 | Identity Data - Design Option: Main Model
3065064 | 90 | -10 | 1730 | Identity Data - Design Option: Main Model
3065070 | 90 | -10 | 1736 | Identity Data - Design Option: Main Model
3065076 | 90 | -10 | 1742 | Identity Data - Design Option: Main Model
3065090 | 90 | -20.5 | 1756
3065104 | 90 | -20.5 | 1770
3065108 | 90 | -20.5 | 1774
3065118 | 90 | -20.5 | 1784 | Identity Data - Design Option: Main Model
3065122 | 90 | -20.5 | 1788
3065132 | 90 | -11 | 1798 | Identity Data - Design Option: Main Model
3065146 | 90 | -11 | 1812 | Identity Data - Design Option: Main Model
3065160 | 90 | -14 | 1826
3069434 | 59 | -20 | 1876
3069487 | 59 | -20 | 1879 | Identity Data - Design Option: Main Model
3069634 | 59 | -20 | 1882
3069698 | 59 | -20 | 1885 | Identity Data - Design Option: Main Model
3070326 | 90 | -30 | 1895
3070537 | 90 | -20 | 1899 | Identity Data - Design Option: Main Model
3072146 | 90 | -27 | 1908 | Identity Data - Design Option: Main Model
3072390 | 90 | -27 | 1914
3072675 | 59 | -20 | 1919 | Identity Data - Design Option: Main Model
3072916 | 59 | -20 | 1923
3083489 | 90 | -25 | 2078
3083492 | 90 | -25 | 2081
3083495 | 90 | -25 | 2084
3083498 | 90 | -25 | 2087
3083501 | 90 | -25 | 2090
3083504 | 90 | -25 | 2093 | Identity Data - Design Option: Main Model
3083507 | 90 | -25 | 2096 | Identity Data - Design Option: Main Model
3083510 | 90 | -25 | 2099
3083513 | 90 | -25 | 2102
3083516 | 90 | -25 | 2105 | Identity Data - Design Option: Main Model
3083519 | 90 | -25 | 2108
3083522 | 90 | -25 | 2111
3083525 | 90 | -25 | 2114
3083528 | 90 | -25 | 2117
3083531 | 90 | -25 | 2120 | Identity Data - Design Option: Main Model
3083538 | 90 | -25 | 2127
3083540 | 90 | -25 | 2129 | Identity Data - Design Option: Main Model
3083566 | 90 | -10 | 2155
3083572 | 90 | -10 | 2161
3083578 | 90 | -10 | 2167
3083592 | 90 | -20.5 | 2181
3083606 | 90 | -20.5 | 2195
3083610 | 90 | -20.5 | 2199 | Identity Data - Design Option: Main Model
3083620 | 90 | -20.5 | 2209
3083624 | 90 | -20.5 | 2213
3083634 | 90 | -11 | 2223
3083648 | 90 | -11 | 2237 | Identity Data - Design Option: Main Model
3083662 | 90 | -14 | 2251
3083936 | 59 | -20 | 2336 | Identity Data - Design Option: Main Model
3083939 | 59 | -20 | 2339
3083942 | 59 | -20 | 2342
3083945 | 59 | -20 | 2345
3083950 | 90 | -30 | 2350 | Identity Data - Design Option: Main Model
3083954 | 90 | -20 | 2354
3083977 | 90 | -27 | 2359
3083983 | 90 | -27 | 2365 | Identity Data - Design Option: Main Model
3083988 | 59 | -20 | 2370
3083992 | 59 | -20 | 2374
3084135 | 90 | -10 | 2435
3084141 | 90 | -10 | 2441 | Identity Data - Design Option: Main Model
3084147 | 90 | -10 | 2447
3085260 | 90 | -27 | 2477
3085921 | 90 | -25 | 2492 | Identity Data - Design Option: Main Model
3086019 | 90 | -25 | 2494 | Identity Data - Design Option: Main Model
3372465 | 90 | -9 | 2545
3373131 | 90 | -9 | 2559 | Identity Data - Design Option: Main Model
3935621 | 90 | -37 | 2610 | Identity Data - Design Option: Main Model
3935624 | 90 | -37 | 2613
3935627 | 90 | -37 | 2616
3935716 | 90 | -37 | 2628 | Identity Data - Design Option: Main Model
3935719 | 90 | -37 | 2631 | Identity Data - Design Option: Main Model
3935722 | 90 | -37 | 2634
3935754 | 90 | -37 | 2646 | Identity Data - Design Option: Main Model
3935757 | 90 | -37 | 2649 | Identity Data - Design Option: Main Model
3935760 | 90 | -37 | 2652
3935787 | 90 | -37 | 2664
3935790 | 90 | -37 | 2667
3935793 | 90 | -37 | 2670 | Identity Data - Design Option: Main Model

# IfcFlowTerminal: zijuitloop laag 40mm (137)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat)
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Multi; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24; OmniClass Title: Waste Water Drains; Type Name: zijuitloop laag 40mm; URL: http://www.easydrain.nl/nl/easy-drain/multi/multi.html
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: zijuitloop laag 40mm
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Siphon Orientation: 0 deg; Waterseal: 30 mm
Dimensions - a: 180 deg; D: 102 mm; Do: 40 mm; E: 20 mm; NLRS_C_diameter: 102 mm; NLRS_P_c01_diameter: 40 mm; Z1: 91 mm
Identity Data - NLRS_C_code_product: EDMSI 6; NLRS_C_omschrijving: Multi Sifon
Other - Family: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon uitloop_Easydrain: zijuitloop laag 40mm; Family and Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon uitloop_Easydrain: zijuitloop laag 40mm; H_siphon: 51 mm; product_index: 1; R: 51 mm; ro: 20 mm; Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon uitloop_Easydrain: zijuitloop laag 40mm; Type Id: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon uitloop_Easydrain: zijuitloop laag 40mm
Phasing - Phase Created: New Construction
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon uitloop_Easydrain:zijuitloop laag 40mm:...) | H (mm) = NLRS_C_hoogte (mm) = H_calculated (mm) | Offset (mm) | Volume (m3) | Mark | Design Option
3051618 | 59 | -25 | 0.000478345 | 1053
3051699 | 59 | -25 | 0.000478345 | 1056 | Main Model
3051814 | 59 | -25 | 0.000478345 | 1059
3053111 | 59 | -25 | 0.000478345 | 1062
3053114 | 59 | -25 | 0.000478345 | 1065
3053117 | 59 | -25 | 0.000478345 | 1068
3053127 | 59 | -25 | 0.000478345 | 1071 | Main Model
3053130 | 59 | -25 | 0.000478345 | 1074
3053133 | 59 | -25 | 0.000478345 | 1077 | Main Model
3053143 | 59 | -25 | 0.000478345 | 1080
3053146 | 59 | -25 | 0.000478345 | 1083 | Main Model
3053149 | 59 | -25 | 0.000478345 | 1086
3053161 | 59 | -25 | 0.000478345 | 1089 | Main Model
3053164 | 59 | -25 | 0.000478345 | 1092
3053167 | 59 | -25 | 0.000478345 | 1095 | Main Model
3053821 | 59 | -25 | 0.000478345 | 1197 | Main Model
3053903 | 59 | -25 | 0.000478345 | 1199 | Main Model
3058131 | 54 | -27 | 0.000473146 | 1272
3058214 | 54 | -27 | 0.000473146 | 1275
3058309 | 54 | -27 | 0.000473146 | 1278 | Main Model
3058368 | 54 | -27 | 0.000473146 | 1281 | Main Model
3060082 | 59 | -25 | 0.000478345 | 1324 | Main Model
3060085 | 59 | -25 | 0.000478345 | 1327
3060088 | 59 | -25 | 0.000478345 | 1330
3060091 | 59 | -25 | 0.000478345 | 1333 | Main Model
3060094 | 59 | -25 | 0.000478345 | 1336 | Main Model
3060097 | 59 | -25 | 0.000478345 | 1339 | Main Model
3060100 | 59 | -25 | 0.000478345 | 1342
3060103 | 59 | -25 | 0.000478345 | 1345
3060106 | 59 | -25 | 0.000478345 | 1348
3060109 | 59 | -25 | 0.000478345 | 1351 | Main Model
3060112 | 59 | -25 | 0.000478345 | 1354
3060115 | 59 | -25 | 0.000478345 | 1357
3060118 | 59 | -25 | 0.000478345 | 1360
3060121 | 59 | -25 | 0.000478345 | 1363 | Main Model
3060124 | 59 | -25 | 0.000478345 | 1366 | Main Model
3060219 | 59 | -25 | 0.000478345 | 1414 | Main Model
3060221 | 59 | -25 | 0.000478345 | 1416
3060247 | 54 | -10 | 0.000473146 | 1422
3060495 | 54 | -10 | 0.000473146 | 1430
3060565 | 54 | -10 | 0.000473146 | 1438 | Main Model
3060669 | 59 | -20.5 | 0.000478345 | 1470 | Main Model
3061520 | 59 | -20.5 | 0.000478345 | 1484 | Main Model
3061592 | 59 | -20.5 | 0.000478345 | 1498 | Main Model
3061634 | 59 | -11 | 0.000478345 | 1512 | Main Model
3062432 | 59 | -11 | 0.000478345 | 1526
3062479 | 54 | -14 | 0.000473146 | 1540 | Main Model
3064942 | 59 | -25 | 0.000478345 | 1608 | Main Model
3064945 | 59 | -25 | 0.000478345 | 1611 | Main Model
3064948 | 59 | -25 | 0.000478345 | 1614
3064951 | 59 | -25 | 0.000478345 | 1617
3064954 | 59 | -25 | 0.000478345 | 1620
3064957 | 59 | -25 | 0.000478345 | 1623
3064960 | 59 | -25 | 0.000478345 | 1626
3064963 | 59 | -25 | 0.000478345 | 1629
3064966 | 59 | -25 | 0.000478345 | 1632 | Main Model
3064969 | 59 | -25 | 0.000478345 | 1635 | Main Model
3064972 | 59 | -25 | 0.000478345 | 1638
3064975 | 59 | -25 | 0.000478345 | 1641 | Main Model
3064978 | 59 | -25 | 0.000478345 | 1644 | Main Model
3064981 | 59 | -25 | 0.000478345 | 1647
3064984 | 59 | -25 | 0.000478345 | 1650
3065032 | 59 | -25 | 0.000478345 | 1698
3065034 | 59 | -25 | 0.000478345 | 1700 | Main Model
3065040 | 54 | -10 | 0.000473146 | 1706 | Main Model
3065048 | 54 | -10 | 0.000473146 | 1714
3065056 | 54 | -10 | 0.000473146 | 1722
3065082 | 59 | -20.5 | 0.000478345 | 1748 | Main Model
3065096 | 59 | -20.5 | 0.000478345 | 1762
3065110 | 59 | -20.5 | 0.000478345 | 1776
3065124 | 59 | -11 | 0.000478345 | 1790
3065138 | 59 | -11 | 0.000478345 | 1804
3065152 | 54 | -14 | 0.000473146 | 1818
3067915 | 59 | -20 | 0.000478345 | 1858 | Main Model
3068591 | 59 | -20 | 0.000478345 | 1861 | Main Model
3068657 | 59 | -20 | 0.000478345 | 1864 | Main Model
3070154 | 59 | -30 | 0.000478345 | 1891 | Main Model
3070457 | 59 | -20 | 0.000478345 | 1897 | Main Model
3072081 | 54 | -27 | 0.000473146 | 1905 | Main Model
3072314 | 54 | -27 | 0.000473146 | 1911
3072498 | 59 | -20 | 0.000478345 | 1917
3072796 | 59 | -20 | 0.000478345 | 1921
3083444 | 59 | -25 | 0.000478345 | 2033 | Main Model
3083447 | 59 | -25 | 0.000478345 | 2036 | Main Model
3083450 | 59 | -25 | 0.000478345 | 2039 | Main Model
3083453 | 59 | -25 | 0.000478345 | 2042 | Main Model
3083456 | 59 | -25 | 0.000478345 | 2045 | Main Model
3083459 | 59 | -25 | 0.000478345 | 2048
3083462 | 59 | -25 | 0.000478345 | 2051 | Main Model
3083465 | 59 | -25 | 0.000478345 | 2054 | Main Model
3083468 | 59 | -25 | 0.000478345 | 2057 | Main Model
3083471 | 59 | -25 | 0.000478345 | 2060
3083474 | 59 | -25 | 0.000478345 | 2063 | Main Model
3083477 | 59 | -25 | 0.000478345 | 2066
3083480 | 59 | -25 | 0.000478345 | 2069 | Main Model
3083483 | 59 | -25 | 0.000478345 | 2072
3083486 | 59 | -25 | 0.000478345 | 2075 | Main Model
3083534 | 59 | -25 | 0.000478345 | 2123 | Main Model
3083536 | 59 | -25 | 0.000478345 | 2125 | Main Model
3083542 | 54 | -10 | 0.000473146 | 2131 | Main Model
3083550 | 54 | -10 | 0.000473146 | 2139
3083558 | 54 | -10 | 0.000473146 | 2147 | Main Model
3083584 | 59 | -20.5 | 0.000478345 | 2173
3083598 | 59 | -20.5 | 0.000478345 | 2187
3083612 | 59 | -20.5 | 0.000478345 | 2201 | Main Model
3083626 | 59 | -11 | 0.000478345 | 2215 | Main Model
3083640 | 59 | -11 | 0.000478345 | 2229
3083654 | 54 | -14 | 0.000473146 | 2243
3083924 | 59 | -20 | 0.000478345 | 2324
3083927 | 59 | -20 | 0.000478345 | 2327 | Main Model
3083930 | 59 | -20 | 0.000478345 | 2330 | Main Model
3083948 | 59 | -30 | 0.000478345 | 2348
3083952 | 59 | -20 | 0.000478345 | 2352 | Main Model
3083974 | 54 | -27 | 0.000473146 | 2356 | Main Model
3083980 | 54 | -27 | 0.000473146 | 2362
3083986 | 59 | -20 | 0.000478345 | 2368 | Main Model
3083990 | 59 | -20 | 0.000478345 | 2372 | Main Model
3084111 | 54 | -10 | 0.000473146 | 2411
3084119 | 54 | -10 | 0.000473146 | 2419 | Main Model
3084127 | 54 | -10 | 0.000473146 | 2427 | Main Model
3084811 | 54 | -27 | 0.000473146 | 2465 | Main Model
3085763 | 59 | -25 | 0.000478345 | 2488
3085833 | 59 | -25 | 0.000478345 | 2490
3372090 | 80 | -9 | 0.000501424 | 2537 | Main Model
3372787 | 80 | -9 | 0.000501424 | 2551 | Main Model
3935440 | 59 | -37 | 0.000478345 | 2601 | Main Model
3935565 | 59 | -37 | 0.000478345 | 2604 | Main Model
3935572 | 59 | -37 | 0.000478345 | 2607 | Main Model
3935707 | 59 | -37 | 0.000478345 | 2619 | Main Model
3935710 | 59 | -37 | 0.000478345 | 2622 | Main Model
3935713 | 59 | -37 | 0.000478345 | 2625 | Main Model
3935745 | 59 | -37 | 0.000478345 | 2637
3935748 | 59 | -37 | 0.000478345 | 2640
3935751 | 59 | -37 | 0.000478345 | 2643
3935778 | 59 | -37 | 0.000478345 | 2655 | Main Model
3935781 | 59 | -37 | 0.000478345 | 2658 | Main Model
3935784 | 59 | -37 | 0.000478345 | 2661

# IfcFlowTerminal: zijuitloop laag 50mm (35)
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: 52.31 (Uniformat)
Type - General - NLRS_C_content_creator: Itannex; NLRS_C_content_provider: EasyDrain
Type - Identity Data - Assembly Code: 52.31; Description: Draingoot horizontale uitlaat; Manufacturer: Easy Sanitary Solutions; Model: Multi; NLRS_C_bestemming: Showerdrains; NLRS_C_code_ETIM: EC011737; NLRS_P_c01_aansluitmethode: Lijmverbinding; OmniClass Number: 23.70.50.21.24; OmniClass Title: Waste Water Drains; Type Name: zijuitloop laag 50mm; URL: http://www.easydrain.nl/nl/easy-drain/multi/multi.html
Type - Mechanical - NLRS_P_c01_volumestroom: 0 m3/s
Type - Other - Category: Plumbing Fixtures; Family Name: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon uitloop_Easydrain
Pset_ManufacturerTypeInformation - Manufacturer: Easy Sanitary Solutions
Pset_DistributionFlowElementCommon - Reference: zijuitloop laag 50mm
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Siphon Orientation: 0 deg; Host: Level : Level 1
Dimensions - a: 180 deg; D: 102 mm; Do: 50 mm; NLRS_C_diameter: 102 mm; NLRS_P_c01_diameter: 50 mm; Z1: 91 mm
Identity Data - NLRS_C_code_product: EDMSI; NLRS_C_omschrijving: Multi Sifon
Other - Family: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon uitloop_Easydrain: zijuitloop laag 50mm; Family and Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon uitloop_Easydrain: zijuitloop laag 50mm; H_siphon: 56 mm; R: 51 mm; ro: 25 mm; Type: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon uitloop_Easydrain: zijuitloop laag 50mm; Type Id: Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon uitloop_Easydrain: zijuitloop laag 50mm
Phasing - Phase Created: New Construction
Name (Z_DO_NOT_USE_NLRS_PF_52_UN_Multi sifon uitloop_Easydrain:zijuitloop laag 50mm:...) | H (mm) | Offset (mm) | Waterseal (mm) | E (mm) | NLRS_C_hoogte (mm) = H_calculated (mm) | Volume (m3) | Design Option | Mark | product_index
3060413 | 54 | -10 | 30 | 25 | 59 | 0.000544135 | Main Model | 1424 | 3
3060497 | 54 | -10 | 30 | 25 | 59 | 0.000544135 | Main Model | 1432 | 3
3060567 | 54 | -10 | 30 | 25 | 59 | 0.000544135 |  | 1440 | 3
3060851 | 59 | -20.5 | 30 | 25 | 59 | 0.000544135 | Main Model | 1472 | 3
3061522 | 59 | -20.5 | 30 | 25 | 59 | 0.000544135 |  | 1486 | 3
3061594 | 59 | -20.5 | 30 | 25 | 59 | 0.000544135 | Main Model | 1500 | 3
3061928 | 59 | -11 | 30 | 25 | 59 | 0.000544135 |  | 1514 | 3
3062434 | 59 | -11 | 30 | 25 | 59 | 0.000544135 | Main Model | 1528 | 3
3062652 | 54 | -14 | 30 | 25 | 59 | 0.000544135 |  | 1542 | 3
3065042 | 54 | -10 | 30 | 25 | 59 | 0.000544135 |  | 1708 | 3
3065050 | 54 | -10 | 30 | 25 | 59 | 0.000544135 | Main Model | 1716 | 3
3065058 | 54 | -10 | 30 | 25 | 59 | 0.000544135 | Main Model | 1724 | 3
3065084 | 59 | -20.5 | 30 | 25 | 59 | 0.000544135 | Main Model | 1750 | 3
3065098 | 59 | -20.5 | 30 | 25 | 59 | 0.000544135 |  | 1764 | 3
3065112 | 59 | -20.5 | 30 | 25 | 59 | 0.000544135 |  | 1778 | 3
3065126 | 59 | -11 | 30 | 25 | 59 | 0.000544135 |  | 1792 | 3
3065140 | 59 | -11 | 30 | 25 | 59 | 0.000544135 | Main Model | 1806 | 3
3065154 | 54 | -14 | 30 | 25 | 59 | 0.000544135 | Main Model | 1820 | 3
3068810 | 59 | -20 | 30 | 25 | 59 | 0.000544135 |  | 1870 | 3
3083544 | 54 | -10 | 30 | 25 | 59 | 0.000544135 | Main Model | 2133 | 3
3083552 | 54 | -10 | 30 | 25 | 59 | 0.000544135 | Main Model | 2141 | 3
3083560 | 54 | -10 | 30 | 25 | 59 | 0.000544135 | Main Model | 2149 | 3
3083586 | 59 | -20.5 | 30 | 25 | 59 | 0.000544135 |  | 2175 | 3
3083600 | 59 | -20.5 | 30 | 25 | 59 | 0.000544135 |  | 2189 | 3
3083614 | 59 | -20.5 | 30 | 25 | 59 | 0.000544135 | Main Model | 2203 | 3
3083628 | 59 | -11 | 30 | 25 | 59 | 0.000544135 | Main Model | 2217 | 3
3083642 | 59 | -11 | 30 | 25 | 59 | 0.000544135 |  | 2231 | 3
3083656 | 54 | -14 | 30 | 25 | 59 | 0.000544135 | Main Model | 2245 | 3
3083933 | 59 | -20 | 30 | 25 | 59 | 0.000544135 |  | 2333 | 3
3084113 | 54 | -10 | 30 | 25 | 59 | 0.000544135 |  | 2413 | 3
3084121 | 54 | -10 | 30 | 25 | 59 | 0.000544135 |  | 2421 | 3
3084129 | 54 | -10 | 30 | 25 | 59 | 0.000544135 |  | 2429 | 3
3084957 | 59 | -27 | 30 | 25 | 59 | 0.000544135 |  | 2468 | 3
3372223 | 80 | -9 | 35 | 23 | 80 | 0.000567639 | Main Model | 2539 | 4
3372867 | 80 | -9 | 35 | 23 | 80 | 0.000567639 | Main Model | 2553 | 4
